# Repository cherry-takuan/nlp

## KiCad design nlp-16a/Hardware/A_B_BUS_Ctrl/A_B_BUS_Ctrl/A_B_BUS_Ctrl.kicad_pcb

Board: 2 copper layers, 209.6 x 154.9 mm, 56 parts (0 on the bottom side), 202 nets.

Parts:
C1: C_Polarized; CP_Radial_D5.0mm_P2.50mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
J1, J4: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J2, J3, J5, J6: Conn_02x10_Counter_Clockwise; PinHeader_2x10_P2.54mm_Vertical
J7: Conn_02x10_Counter_Clockwise; PinHeader_2x10_P2.54mm_Horizontal
J8: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24, U25, U26, U27, U28, U29, U30, U31, U32, U33, U34, U35, U36, U37, U38, U39, U40, U41, U42, U43: CD74HC00; DIP-14_W7.62mm

Connections:
/BUS_OUTPUT_Correction/Correction0/Correction: U1.1, U1.5, U2.1, U2.5, U3.1, U3.5, U4.1, U4.5, U5.1, U5.5, U6.1, U6.5, U7.1, U7.5, U8.1, U8.5, U9.1, U9.5, U10.1, U10.5, U11.1, U11.5, U12.1, U12.5, U13.1, U13.5, U14.1, U14.5, U15.1, U15.5, U16.1, U16.5, U43.3
/address_decoder/decoder0/A: U37.1, U37.4, U38.1, U38.4, U39.1, U39.4, U40.1, U40.4, U41.8
/address_decoder/decoder0/B: U35.2, U35.5, U36.2, U36.5, U39.2, U39.5, U40.2, U40.5, U41.6
/address_decoder/decoder0/C: U26.1, U28.1, U28.4, U30.1, U30.4, U32.1, U32.4, U42.8
/address_decoder/decoder0/D: U17.4, U19.4, U20.4, U21.4, U22.4, U23.4, U24.4, U42.6
/address_decoder/decoder1/D: U17.1, U18.1, U19.1, U20.1, U21.1, U22.1, U23.1, U24.1, U42.3, U42.4, U42.5
/address_decoder/decoder10/A: U33.1, U33.4, U34.1, U34.4, U35.1, U35.4, U36.1, U36.4, U41.9, U41.10, U41.11
/address_decoder/decoder10/C: U25.1, U25.4, U27.1, U27.4, U29.1, U29.4, U31.1, U31.4, U42.9, U42.10, U42.11
/address_decoder/decoder12/B: U33.2, U33.5, U34.2, U34.5, U37.2, U37.5, U38.2, U38.5, U41.3, U41.4, U41.5
Correction: J1.33, U43.1
DATA0: J2.19, J5.19, U16.8
DATA1: J2.17, J5.17, U15.8
DATA2: J2.15, J5.15, U14.8
DATA3: J2.13, J5.13, U13.8
DATA4: J2.11, J5.11, U12.8
DATA5: J2.9, J5.9, U11.8
DATA6: J2.7, J5.7, U10.8
DATA7: J2.5, J5.5, U9.8
DATA8: J3.19, J6.19, U8.8
DATA9: J3.17, J6.17, U7.8
DATA10: J3.15, J6.15, U6.8
DATA11: J3.13, J6.13, U5.8
DATA12: J3.11, J6.11, U4.8
DATA13: J3.9, J6.9, U3.8
DATA14: J3.7, J6.7, U2.8
DATA15: J3.5, J6.5, U1.8
Decoded_Reg_Addr0: J1.32, J4.32, U24.8
Decoded_Reg_Addr1: J1.30, J4.30, U24.11
Decoded_Reg_Addr2: J1.28, J4.28, U23.8
Decoded_Reg_Addr3: J1.26, J4.26, U23.11
Decoded_Reg_Addr4: J1.24, J4.24, U22.8
Decoded_Reg_Addr5: J1.22, J4.22, U22.11
Decoded_Reg_Addr6: J1.20, J4.20, U21.8
Decoded_Reg_Addr7: J1.18, J4.18, U21.11
Decoded_Reg_Addr8: J1.16, J4.16, U20.8
Decoded_Reg_Addr9: J1.14, J4.14, U20.11
Decoded_Reg_Addr10: J1.12, J4.12, U19.8
Decoded_Reg_Addr11: J1.10, J4.10, U19.11
Decoded_Reg_Addr12: J1.8, J4.8, U18.8
Decoded_Reg_Addr13: J1.6, J4.6, U18.11
Decoded_Reg_Addr14: J1.4, J4.4, U17.8
Decoded_Reg_Addr15: J1.2, J4.2, U17.11
GND: C1.2, H1.1, H2.1, H3.1, H4.1, J1.37, J1.39, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J3.18, J3.20, J4.37, J4.39, J5.2, J5.4, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, J5.18, J5.20, J6.2, J6.4, J6.6, J6.8, J6.10, J6.12, J6.14, J6.16, J6.18, J6.20, J7.16, J7.18, J7.20, J8.1, U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.7 (GND), U5.7 (GND), U6.7 (GND), U7.7 (GND), U8.7 (GND), U9.7 (GND), U10.7 (GND), U11.7 (GND), U12.7 (GND), U13.7 (GND), U14.7 (GND), U15.7 (GND), U16.7 (GND), U17.7 (GND), U18.7 (GND), U19.7 (GND), U20.7 (GND), U21.7 (GND), U22.7 (GND), U23.7 (GND), U24.7 (GND), U25.7 (GND), U26.7 (GND), U27.7 (GND), U28.7 (GND), U29.7 (GND), U30.7 (GND), U31.7 (GND), U32.7 (GND), U33.7 (GND), U34.7 (GND), U35.7 (GND), U36.7 (GND), U37.7 (GND), U38.7 (GND), U39.7 (GND), U40.7 (GND), U41.7 (GND), U42.7 (GND), U43.4, U43.5, U43.7 (GND), U43.9, U43.10, U43.12, U43.13
unnamed: U1.6, U1.9
unnamed: U1.10, U1.11
unnamed: U1.3, U1.4, U1.12
unnamed: U2.6, U2.9
unnamed: U2.10, U2.11
unnamed: U2.3, U2.4, U2.12
unnamed: U3.6, U3.9
unnamed: U3.10, U3.11
unnamed: U3.3, U3.4, U3.12
unnamed: U4.6, U4.9
unnamed: U4.10, U4.11
unnamed: U4.3, U4.4, U4.12
unnamed: U5.6, U5.9
unnamed: U5.10, U5.11
unnamed: U5.3, U5.4, U5.12
unnamed: U6.6, U6.9
unnamed: U6.10, U6.11
unnamed: U6.3, U6.4, U6.12
unnamed: U7.6, U7.9
unnamed: U7.10, U7.11
unnamed: U7.3, U7.4, U7.12
unnamed: U8.6, U8.9
unnamed: U8.10, U8.11
unnamed: U8.3, U8.4, U8.12
unnamed: U9.6, U9.9
unnamed: U9.10, U9.11
unnamed: U9.3, U9.4, U9.12
unnamed: U10.6, U10.9
unnamed: U10.10, U10.11
unnamed: U10.3, U10.4, U10.12
unnamed: U11.6, U11.9
unnamed: U11.10, U11.11
unnamed: U11.3, U11.4, U11.12
unnamed: U12.6, U12.9
unnamed: U12.10, U12.11
unnamed: U12.3, U12.4, U12.12
unnamed: U13.6, U13.9
unnamed: U13.10, U13.11
unnamed: U13.3, U13.4, U13.12
unnamed: U14.6, U14.9
unnamed: U14.10, U14.11
unnamed: U14.3, U14.4, U14.12
unnamed: U15.6, U15.9
unnamed: U15.10, U15.11
unnamed: U15.3, U15.4, U15.12
unnamed: U16.6, U16.9
unnamed: U16.10, U16.11
unnamed: U16.3, U16.4, U16.12
unnamed: U17.2, U25.11
unnamed: U17.5, U25.8
unnamed: U17.6, U17.9
unnamed: U17.3, U17.12
unnamed: U18.2, U26.11
unnamed: U18.5, U26.8
unnamed: U18.6, U18.9
unnamed: U18.3, U18.12
unnamed: U19.2, U27.11
unnamed: U19.5, U27.8
unnamed: U19.6, U19.9
unnamed: U19.3, U19.12
unnamed: U20.2, U28.11
unnamed: U20.5, U28.8
unnamed: U20.6, U20.9
unnamed: U20.3, U20.12
unnamed: U21.2, U29.11
unnamed: U21.5, U29.8
unnamed: U21.6, U21.9
unnamed: U21.3, U21.12
unnamed: U22.2, U30.11
unnamed: U22.5, U30.8
unnamed: U22.6, U22.9
unnamed: U22.3, U22.12
unnamed: U23.2, U31.11
unnamed: U23.5, U31.8
unnamed: U23.6, U23.9
unnamed: U23.3, U23.12
unnamed: U24.2, U32.11
unnamed: U24.5, U32.8
unnamed: U24.6, U24.9
unnamed: U24.3, U24.12
unnamed: U25.2, U33.11
unnamed: U25.5, U33.8
unnamed: U25.6, U25.9, U25.10
unnamed: U25.3, U25.12, U25.13
unnamed: U26.2, U34.11
unnamed: U26.5, U34.8
unnamed: U26.6, U26.9, U26.10
unnamed: U26.3, U26.12, U26.13
unnamed: U27.2, U35.11
unnamed: U27.5, U35.8
unnamed: U27.6, U27.9, U27.10
unnamed: U27.3, U27.12, U27.13
unnamed: U28.2, U36.11
unnamed: U28.5, U36.8
unnamed: U28.6, U28.9, U28.10
unnamed: U28.3, U28.12, U28.13
unnamed: U29.2, U37.11
unnamed: U29.5, U37.8
unnamed: U29.6, U29.9, U29.10
unnamed: U29.3, U29.12, U29.13
unnamed: U30.2, U38.11
unnamed: U30.5, U38.8
unnamed: U30.6, U30.9, U30.10
unnamed: U30.3, U30.12, U30.13
unnamed: U31.2, U39.11
unnamed: U31.5, U39.8
unnamed: U31.6, U31.9, U31.10
unnamed: U31.3, U31.12, U31.13
unnamed: U32.2, U40.11
unnamed: U32.5, U40.8
unnamed: U32.6, U32.9, U32.10
unnamed: U32.3, U32.12, U32.13
unnamed: U33.6, U33.9, U33.10
unnamed: U33.3, U33.12, U33.13
unnamed: U34.6, U34.9, U34.10
unnamed: U34.3, U34.12, U34.13
unnamed: U35.6, U35.9, U35.10
unnamed: U35.3, U35.12, U35.13
unnamed: U36.6, U36.9, U36.10
unnamed: U36.3, U36.12, U36.13
unnamed: U37.6, U37.9, U37.10
unnamed: U37.3, U37.12, U37.13
unnamed: U38.6, U38.9, U38.10
unnamed: U38.3, U38.12, U38.13
unnamed: U39.6, U39.9, U39.10
unnamed: U39.3, U39.12, U39.13
unnamed: U40.6, U40.9, U40.10
unnamed: U40.3, U40.12, U40.13
RAW_DATA0: J1.31, J4.31, U16.2, U16.13
RAW_DATA1: J1.29, J4.29, U15.2, U15.13
RAW_DATA2: J1.27, J4.27, U14.2, U14.13
RAW_DATA3: J1.25, J4.25, U13.2, U13.13
RAW_DATA4: J1.23, J4.23, U12.2, U12.13
RAW_DATA5: J1.21, J4.21, U11.2, U11.13
RAW_DATA6: J1.19, J4.19, U10.2, U10.13
RAW_DATA7: J1.17, J4.17, U9.2, U9.13
RAW_DATA8: J1.15, J4.15, U8.2, U8.13
RAW_DATA9: J1.13, J4.13, U7.2, U7.13
RAW_DATA10: J1.11, J4.11, U6.2, U6.13
RAW_DATA11: J1.9, J4.9, U5.2, U5.13
RAW_DATA12: J1.7, J4.7, U4.2, U4.13
RAW_DATA13: J1.5, J4.5, U3.2, U3.13
RAW_DATA14: J1.3, J4.3, U2.2, U2.13
RAW_DATA15: J1.1, J4.1, U1.2, U1.13
Reg_Addr0: J7.2, U42.1, U42.13
Reg_Addr1: J7.4, U41.2, U42.12
Reg_Addr2: J7.6, U41.1, U41.13
Reg_Addr3: J7.8, U41.12
VCC: C1.1, J1.35, J1.38, J1.40, J4.38, J4.40, J8.2, U1.14 (VCC), U2.14 (VCC), U3.14 (VCC), U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.14 (VCC), U8.14 (VCC), U9.14 (VCC), U10.14 (VCC), U11.14 (VCC), U12.14 (VCC), U13.14 (VCC), U14.14 (VCC), U15.14 (VCC), U16.14 (VCC), U17.13, U17.14 (VCC), U18.4, U18.14 (VCC), U19.10, U19.14 (VCC), U20.10, U20.13, U20.14 (VCC), U21.10, U21.13, U21.14 (VCC), U22.13, U22.14 (VCC), U23.14 (VCC), U24.14 (VCC), U25.14 (VCC), U26.4, U26.14 (VCC), U27.14 (VCC), U28.14 (VCC), U29.14 (VCC), U30.14 (VCC), U31.14 (VCC), U32.14 (VCC), U33.14 (VCC), U34.14 (VCC), U35.14 (VCC), U36.14 (VCC), U37.14 (VCC), U38.14 (VCC), U39.14 (VCC), U40.14 (VCC), U41.14 (VCC), U42.14 (VCC), U43.2, U43.14 (VCC)
~Address: J7.5, U18.10
~Flag: J7.9, U22.10
~INTERNAL: J7.19, U42.2
~IP: J7.3, U18.13
~IR1: J7.17, U24.10
~IR2: J7.15, U24.13
~IR3: J7.13, U23.10
~IV: J7.11, U23.13
~MEM: J7.7, U19.13
~SP: J7.1, U17.10

## KiCad design nlp-16a/Hardware/Accumulator/Accumulator.kicad_pcb

Board: 2 copper layers, 209.6 x 154.9 mm, 62 parts (0 on the bottom side), 119 nets, no tracks yet.

Parts:
C1: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
J1: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J2, J3: Conn_02x10_Counter_Clockwise; PinHeader_2x10_P2.54mm_Vertical
J4: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2: R_Network08_Split; R_Array_SIP9
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17: CD74HC00; DIP-14_W7.62mm

Connections:
/Acc0/Gate: U9.2, U9.5, U10.2, U10.5, U11.2, U11.5, U12.2, U12.5, U13.2, U13.5, U14.2, U14.5, U15.2, U15.5, U16.2, U16.5, U17.6
/Acc0/Q: D1.2 (A), R1.1, U16.10, U16.11
/Acc1/Gate: U1.2, U1.5, U2.2, U2.5, U3.2, U3.5, U4.2, U4.5, U5.2, U5.5, U6.2, U6.5, U7.2, U7.5, U8.2, U8.5, U17.8
/Acc1/Q: D2.2 (A), R2.1, U8.10, U8.11
/Acc2/Q: D3.2 (A), R3.1, U15.10, U15.11
/Acc3/Q: D4.2 (A), R4.1, U7.10, U7.11
/Acc4/Q: D5.2 (A), R5.1, U14.10, U14.11
/Acc5/Q: D6.2 (A), R6.1, U6.10, U6.11
/Acc6/Q: D7.2 (A), R7.1, U13.10, U13.11
/Acc7/Q: D8.2 (A), R8.1, U5.10, U5.11
/Acc8/Q: D9.2 (A), R9.1, U12.10, U12.11
/Acc9/Q: D10.2 (A), R10.1, U4.10, U4.11
/Acc10/Q: D11.2 (A), R11.1, U11.10, U11.11
/Acc11/Q: D12.2 (A), R12.1, U3.10, U3.11
/Acc12/Q: D13.2 (A), R13.1, U10.10, U10.11
/Acc13/Q: D14.2 (A), R14.1, U2.10, U2.11
/Acc14/Q: D15.2 (A), R15.1, U9.10, U9.11
/Acc15/Q: D16.2 (A), R16.1, U1.10, U1.11
AccIN0: J4.19, U16.1
AccIN1: J4.17, U8.1
AccIN2: J4.15, U15.1
AccIN3: J4.13, U7.1
AccIN4: J4.11, U14.1
AccIN5: J4.9, U6.1
AccIN6: J4.7, U13.1
AccIN7: J4.5, U5.1
AccIN8: J4.20, U12.1
AccIN9: J4.18, U4.1
AccIN10: J4.16, U11.1
AccIN11: J4.14, U3.1
AccIN12: J4.12, U10.1
AccIN13: J4.10, U2.1
AccIN14: J4.8, U9.1
AccIN15: J4.6, U1.1
GND: C1.2, H1.1, H2.1, H3.1, H4.1, J1.1, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J3.18, J3.20, R17.2, RN1.1 (R1.1), RN2.1 (R1.1), U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.7 (GND), U5.7 (GND), U6.7 (GND), U7.7 (GND), U8.7 (GND), U9.7 (GND), U10.7 (GND), U11.7 (GND), U12.7 (GND), U13.7 (GND), U14.7 (GND), U15.7 (GND), U16.7 (GND), U17.7 (GND)
unnamed: D1.1 (K), RN1.2 (R1.2)
unnamed: D2.1 (K), RN1.3 (R2.2)
unnamed: D3.1 (K), RN1.4 (R3.2)
unnamed: D4.1 (K), RN1.5 (R4.2)
unnamed: D5.1 (K), RN1.6 (R5.2)
unnamed: D6.1 (K), RN1.7 (R6.2)
unnamed: D7.1 (K), RN1.8 (R7.2)
unnamed: D8.1 (K), RN1.9 (R8.2)
unnamed: D9.1 (K), RN2.2 (R1.2)
unnamed: D10.1 (K), RN2.3 (R2.2)
unnamed: D11.1 (K), RN2.4 (R3.2)
unnamed: D12.1 (K), RN2.5 (R4.2)
unnamed: D13.1 (K), RN2.6 (R5.2)
unnamed: D14.1 (K), RN2.7 (R6.2)
unnamed: D15.1 (K), RN2.8 (R7.2)
unnamed: D16.1 (K), RN2.9 (R8.2)
unnamed: D17.1 (K), R17.1
unnamed: U1.6, U1.9
unnamed: U1.3, U1.4, U1.12
unnamed: U1.8, U1.13
unnamed: U2.6, U2.9
unnamed: U2.3, U2.4, U2.12
unnamed: U2.8, U2.13
unnamed: U3.6, U3.9
unnamed: U3.3, U3.4, U3.12
unnamed: U3.8, U3.13
unnamed: U4.6, U4.9
unnamed: U4.3, U4.4, U4.12
unnamed: U4.8, U4.13
unnamed: U5.6, U5.9
unnamed: U5.3, U5.4, U5.12
unnamed: U5.8, U5.13
unnamed: U6.6, U6.9
unnamed: U6.3, U6.4, U6.12
unnamed: U6.8, U6.13
unnamed: U7.6, U7.9
unnamed: U7.3, U7.4, U7.12
unnamed: U7.8, U7.13
unnamed: U8.6, U8.9
unnamed: U8.3, U8.4, U8.12
unnamed: U8.8, U8.13
unnamed: U9.6, U9.9
unnamed: U9.3, U9.4, U9.12
unnamed: U9.8, U9.13
unnamed: U10.6, U10.9
unnamed: U10.3, U10.4, U10.12
unnamed: U10.8, U10.13
unnamed: U11.6, U11.9
unnamed: U11.3, U11.4, U11.12
unnamed: U11.8, U11.13
unnamed: U12.6, U12.9
unnamed: U12.3, U12.4, U12.12
unnamed: U12.8, U12.13
unnamed: U13.6, U13.9
unnamed: U13.3, U13.4, U13.12
unnamed: U13.8, U13.13
unnamed: U14.6, U14.9
unnamed: U14.3, U14.4, U14.12
unnamed: U14.8, U14.13
unnamed: U15.6, U15.9
unnamed: U15.3, U15.4, U15.12
unnamed: U15.8, U15.13
unnamed: U16.6, U16.9
unnamed: U16.3, U16.4, U16.12
unnamed: U16.8, U16.13
unnamed: U17.3, U17.4, U17.5, U17.9, U17.10, U17.12, U17.13
OUT0: J2.19, R1.2
OUT1: J2.17, R2.2
OUT2: J2.15, R3.2
OUT3: J2.13, R4.2
OUT4: J2.11, R5.2
OUT5: J2.9, R6.2
OUT6: J2.7, R7.2
OUT7: J2.5, R8.2
OUT8: J3.19, R9.2
OUT9: J3.17, R10.2
OUT10: J3.15, R11.2
OUT11: J3.13, R12.2
OUT12: J3.11, R13.2
OUT13: J3.9, R14.2
OUT14: J3.7, R15.2
OUT15: J3.5, R16.2
VCC: C1.1, D17.2 (A), J1.2, U1.14 (VCC), U2.14 (VCC), U3.14 (VCC), U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.14 (VCC), U8.14 (VCC), U9.14 (VCC), U10.14 (VCC), U11.14 (VCC), U12.14 (VCC), U13.14 (VCC), U14.14 (VCC), U15.14 (VCC), U16.14 (VCC), U17.14 (VCC)
phi2: J4.1, U17.1, U17.2

## KiCad design nlp-16a/Hardware/Instruction_decoder/Instruction_decoder.kicad_pcb

Notes on the sheet:
制御信号生成
デコードシーケンス
U1 - U48 -ステート保持ユニット(プレフィックスは分けるべきだったかもしれない) U49 - U64 -シーケンス，デコード U65- - 制御信号生成

Parts:
U35, U36: State_hold_unit; PinSocket_1x05_P2.54mm_Vertical
U63, U64, U83, U84: CD74HC00; DIP-14_W7.62mm

Connections:
END_EXE: U63.1, U63.2; also elsewhere on the board
GND: U63.7 (GND), U64.7 (GND), U83.7 (GND), U84.7 (GND), U84.9, U84.10, U84.12, U84.13; also elsewhere on the board
INT_EN: U83.10, U83.11; also elsewhere on the board
INT_START: U64.8; also elsewhere on the board
unnamed: U35.4 (LED), U35.5 (~Q), U36.1 (D), U84.1, U84.4
unnamed: U36.3 (Q), U36.4 (LED)
unnamed: U36.5 (~Q), U63.5
unnamed: U63.3, U63.4
unnamed: U63.6, U64.12
unnamed: U63.8, U64.2
unnamed: U63.10, U63.11
unnamed: U64.1, U64.11
unnamed: U64.3, U64.4, U64.5
unnamed: U64.6, U64.9
unnamed: U83.1, U84.6
unnamed: U83.3, U83.4, U83.5
unnamed: U83.6, U83.9
unnamed: U83.8, U83.12
unnamed: U83.13, U84.3, U84.5
OP0: U84.2; also elsewhere on the board
VCC: U63.14 (VCC), U64.14 (VCC), U83.14 (VCC), U84.14 (VCC); also elsewhere on the board
~->IV_JMP/END_INT: U63.12; also elsewhere on the board
~EI/DI_FETCH: U35.1 (D); also elsewhere on the board
~END_PUSH: U63.13; also elsewhere on the board
~RS: U63.9, U64.13; also elsewhere on the board
~SP_DEC_INT1->: U83.2; also elsewhere on the board
~Seed_pluse: U64.10; also elsewhere on the board

Notes on the sheet:
割り込み許可/禁止保持

Parts:
C1, C2, C3, C4, C5, C6, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23: C; C_Disc_D7.5mm_W2.5mm_P5.00mm
C7: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D1: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
J1, J2: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Horizontal
J3: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J4, J5: Conn_02x10_Counter_Clockwise; PinHeader_2x10_P2.54mm_Horizontal
R1: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U85: CD74HC00; DIP-14_W7.62mm

Connections:
3word: J2.8; also elsewhere on the board
A_BUS_Addr0: J1.12, J5.2
A_BUS_Addr1: J1.10, J5.4
A_BUS_Addr2: J1.8, J5.6
A_BUS_Addr3: J1.6, J5.8
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, H1.1, H2.1, H3.1, H4.1, J1.2, J1.4, J2.2, J2.4, J3.1, J4.16, J4.18, J4.20, J5.16, J5.18, J5.20, R1.2, U85.4, U85.5, U85.7 (GND); also elsewhere on the board
INT: J2.10; also elsewhere on the board
NOP: J2.16, U85.2
unnamed: D1.1 (K), R1.1
unnamed: U85.9, U85.10, U85.11
unnamed: U85.3, U85.13
OP0: J1.19; also elsewhere on the board
OP1: J1.17; also elsewhere on the board
OP2: J1.15
OP3: J1.13
OP4: J1.11; also elsewhere on the board
OP5: J1.9; also elsewhere on the board
OP6: J1.7; also elsewhere on the board
OP7: J1.5; also elsewhere on the board
Reg_pulse: J4.10, U85.8
VCC: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, D1.2 (A), J3.2, U85.14 (VCC); also elsewhere on the board
Y_BUS_Addr0: J1.20, J4.2
Y_BUS_Addr1: J1.18, J4.4
Y_BUS_Addr2: J1.16, J4.6
Y_BUS_Addr3: J1.14, J4.8
Y_Flag_sel: J2.13; also elsewhere on the board
phi1: J2.20, J4.12
phi2: J2.18, U85.12
~Address_Y: J4.5; also elsewhere on the board
~DEC_ALU: J2.15; also elsewhere on the board
~Fetch_Status: J2.11, U85.1; also elsewhere on the board
~Flag_SAVE->: J5.9; also elsewhere on the board
~Flag_Y: J4.9; also elsewhere on the board
~INC_ALU: J2.17; also elsewhere on the board
~INTERNAL_ALU: J2.19; also elsewhere on the board
~INTERNAL_A: J5.19; also elsewhere on the board
~INTERNAL_Y: J4.19; also elsewhere on the board
~IP_A: J5.3; also elsewhere on the board
~IP_Y: J4.3; also elsewhere on the board
~IR1_Y: J4.17; also elsewhere on the board
~IR2_Y: J4.15; also elsewhere on the board
~IR3_Y: J4.11; also elsewhere on the board
~IV_JMP->: J5.13; also elsewhere on the board
~MEM_A: J5.7; also elsewhere on the board
~MEM_Y: J4.7; also elsewhere on the board
~RAM_STORE->: J2.7; also elsewhere on the board
~RS: J2.14, J4.14; also elsewhere on the board
~SP_A: J5.1; also elsewhere on the board
~SP_Y: J4.1; also elsewhere on the board
~Seed_pluse: J2.12; also elsewhere on the board

Notes on the sheet:
YバスではΦ1，Φ2で使用する
Power
Accだけは正論理
BUS_A/~{B}
BUS_A/~{Y}
Yバスでは全レジスタ指定で使用する

Parts:
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14: State_hold_unit; PinSocket_1x05_P2.54mm_Vertical
U49, U50, U51, U52, U53, U54: CD74HC00; DIP-14_W7.62mm

Connections:
3word: U53.1; also elsewhere on the board
EXE_FETCH: U54.6; also elsewhere on the board
Fetch1->: U3.5 (~Q); also elsewhere on the board
Fetch2->: U7.3 (Q); also elsewhere on the board
Fetch3->: U11.3 (Q); also elsewhere on the board
GND: U49.7 (GND), U50.7 (GND), U51.7 (GND), U52.4, U52.5, U52.7 (GND), U53.7 (GND), U54.7 (GND); also elsewhere on the board
unnamed: U1.4 (LED), U1.5 (~Q), U2.1 (D)
unnamed: U2.3 (Q), U2.4 (LED), U3.1 (D)
unnamed: U3.3 (Q), U3.4 (LED), U4.1 (D)
unnamed: U4.3 (Q), U4.4 (LED), U5.1 (D)
unnamed: U5.3 (Q), U5.4 (LED), U6.1 (D)
unnamed: U7.4 (LED), U7.5 (~Q), U8.1 (D)
unnamed: U8.3 (Q), U8.4 (LED), U9.1 (D)
unnamed: U9.3 (Q), U9.4 (LED), U10.1 (D)
unnamed: U10.3 (Q), U10.4 (LED), U53.2, U53.13
unnamed: U11.1 (D), U53.3, U53.12
unnamed: U11.4 (LED), U11.5 (~Q), U12.1 (D)
unnamed: U12.3 (Q), U12.4 (LED), U13.1 (D)
unnamed: U13.3 (Q), U13.4 (LED), U14.1 (D)
unnamed: U14.3 (Q), U14.4 (LED)
unnamed: U49.2, U49.5, U50.3
unnamed: U49.3, U49.4, U50.4, U50.5
unnamed: U7.1 (D), U49.8
unnamed: U6.3 (Q), U6.4 (LED), U49.9, U49.13
unnamed: U50.10, U50.11, U52.12, U52.13
unnamed: U50.6, U50.9, U50.13
unnamed: U51.2, U51.5, U52.3
unnamed: U51.10, U51.13, U52.11
unnamed: U51.11, U52.9
unnamed: U51.8, U51.12, U52.1, U52.2
unnamed: U52.10, U54.8
unnamed: U53.6, U53.9, U53.10, U54.9, U54.13
unnamed: U53.4, U53.11
unnamed: U54.3, U54.12
unnamed: U49.6, U54.4
unnamed: U54.5, U54.10, U54.11
OP1: U51.1; also elsewhere on the board
OP4: U50.12; also elsewhere on the board
OP5: U51.9, U54.1; also elsewhere on the board
OP6: U49.12; also elsewhere on the board
OP7: U49.1, U54.2; also elsewhere on the board
PUSH_FETCH: U52.8; also elsewhere on the board
VCC: U49.14 (VCC), U50.14 (VCC), U51.14 (VCC), U52.14 (VCC), U53.14 (VCC), U54.14 (VCC); also elsewhere on the board
~->IP_INC1: U6.5 (~Q); also elsewhere on the board
~->IP_INC2: U10.5 (~Q); also elsewhere on the board
~->IP_INC3: U14.5 (~Q), U53.5; also elsewhere on the board
~->IP_SET: U2.5 (~Q); also elsewhere on the board
~EI/DI_FETCH: U51.3, U51.4; also elsewhere on the board
~FETCH_INT: U1.1 (D); also elsewhere on the board
~Fetch_END1: U49.10, U49.11, U50.1, U50.2; also elsewhere on the board
~Fetch_END2: U53.8; also elsewhere on the board
~INT_FETCH: U51.6; also elsewhere on the board
~IP_INC1->: U5.5 (~Q); also elsewhere on the board
~IP_INC2->: U9.5 (~Q); also elsewhere on the board
~IP_INC3->: U13.5 (~Q); also elsewhere on the board
~IP_SET->: U1.3 (Q); also elsewhere on the board
~IR1_Y: U4.5 (~Q); also elsewhere on the board
~IR2_Y: U8.5 (~Q); also elsewhere on the board
~IR3_Y: U12.5 (~Q); also elsewhere on the board
~POP_FETCH: U50.8; also elsewhere on the board

Notes on the sheet:
Fetch2
1 1 0 1 X X X X
0 1 X X X X X X
1 1 1 1 X X 0 X
Fetch3
X 0 X X X X X X
Fetch1
1 1 X 0 X X X X
1 1 1 1 X X 1 X
Decode
