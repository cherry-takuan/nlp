# Repository cherry-takuan/nlp (continued)

## KiCad design nlp-16a/Hardware/Instruction_decoder/Instruction_decoder.kicad_pcb (continued)

Parts:
U25, U26, U27, U28: State_hold_unit; PinSocket_1x05_P2.54mm_Vertical
U60: CD74HC00; DIP-14_W7.62mm

Connections:
GND: U60.1, U60.2, U60.7 (GND); also elsewhere on the board
unnamed: U25.3 (Q), U25.4 (LED), U26.1 (D)
unnamed: U26.3 (Q), U26.4 (LED)
unnamed: U27.1 (D), U60.11
unnamed: U27.3 (Q), U27.4 (LED), U28.1 (D)
unnamed: U28.3 (Q), U28.4 (LED), U60.5, U60.10
OP5: U60.4; also elsewhere on the board
PUSH_FETCH: U25.1 (D); also elsewhere on the board
VCC: U60.14 (VCC); also elsewhere on the board
~->RAM_STORE: U28.5 (~Q); also elsewhere on the board
~->SP_DEC_PUSH: U26.5 (~Q), U60.13; also elsewhere on the board
~END_PUSH: U60.8; also elsewhere on the board
~EXE_PUSH: U60.6, U60.9; also elsewhere on the board
~PUSH_EXE: U60.12; also elsewhere on the board
~RAM_STORE->: U27.5 (~Q); also elsewhere on the board
~SP_DEC_PUSH->: U25.5 (~Q); also elsewhere on the board

Parts:
U37, U38: State_hold_unit; PinSocket_1x05_P2.54mm_Vertical
U65, U66, U67, U68, U69, U70, U71, U72, U73, U74, U75, U76, U77, U78, U79, U80, U81, U82: CD74HC00; DIP-14_W7.62mm

Connections:
Fetch1->: U69.2; also elsewhere on the board
Fetch2->: U69.1; also elsewhere on the board
Fetch3->: U69.4; also elsewhere on the board
GND: U65.7 (GND), U66.7 (GND), U67.7 (GND), U68.1, U68.2, U68.4, U68.5, U68.7 (GND), U69.7 (GND), U70.7 (GND), U71.7 (GND), U72.7 (GND), U73.7 (GND), U74.7 (GND), U75.1, U75.2, U75.4, U75.5, U75.7 (GND), U76.7 (GND), U77.7 (GND), U78.7 (GND), U79.7 (GND), U80.7 (GND), U81.1, U81.2, U81.4, U81.5, U81.7 (GND), U82.7 (GND); also elsewhere on the board
INT_START: U82.1, U82.2; also elsewhere on the board
unnamed: U37.1 (D), U82.8, U82.13
unnamed: U37.3 (Q), U37.4 (LED), U38.1 (D)
unnamed: U65.3, U65.4, U65.5
unnamed: U65.6, U66.12
unnamed: U65.8, U66.2, U66.13
unnamed: U65.9, U65.10, U65.11
unnamed: U66.3, U66.4, U66.5
unnamed: U66.6, U80.9
unnamed: U66.8, U76.13
unnamed: U66.9, U66.10, U66.11
unnamed: U67.3, U67.4, U67.5
unnamed: U67.6, U68.12
unnamed: U67.8, U68.13
unnamed: U67.9, U67.10, U67.11
unnamed: U68.8, U76.1
unnamed: U68.9, U68.10, U68.11
unnamed: U69.8, U72.1
unnamed: U69.6, U69.9, U69.10
unnamed: U69.5, U69.11
unnamed: U69.3, U69.12, U69.13
unnamed: U70.9, U71.6
unnamed: U70.10, U70.11
unnamed: U71.3, U71.4, U71.5
unnamed: U71.9, U71.10, U71.11
unnamed: U72.2, U72.8
unnamed: U72.3, U72.4, U72.5
unnamed: U72.9, U72.10, U72.11
unnamed: U73.3, U73.4, U73.5
unnamed: U73.6, U74.5
unnamed: U73.8, U78.4
unnamed: U73.9, U73.10, U73.11
unnamed: U74.8, U79.5
unnamed: U74.6, U74.9, U74.10
unnamed: U74.4, U74.11
unnamed: U74.3, U74.12, U74.13
unnamed: U75.9, U75.10, U75.11
unnamed: U76.3, U76.4, U76.5
unnamed: U76.9, U76.10, U76.11
unnamed: U77.6, U77.9, U77.10
unnamed: U77.4, U77.11
unnamed: U77.3, U77.12, U77.13
unnamed: U78.6, U78.10, U80.1, U80.2
unnamed: U78.5, U78.11
unnamed: U78.3, U78.12, U78.13
unnamed: U79.6, U79.9, U79.10
unnamed: U79.4, U79.11
unnamed: U79.3, U79.12, U79.13
unnamed: U80.8, U81.12
unnamed: U80.4, U80.5, U80.11
unnamed: U81.8, U82.4, U82.5
unnamed: U82.6, U82.9
unnamed: U82.10, U82.11
unnamed: U82.3, U82.12
VCC: U65.14 (VCC), U66.14 (VCC), U67.14 (VCC), U68.14 (VCC), U69.14 (VCC), U70.14 (VCC), U71.14 (VCC), U72.14 (VCC), U73.14 (VCC), U74.14 (VCC), U75.14 (VCC), U76.14 (VCC), U77.14 (VCC), U78.14 (VCC), U79.14 (VCC), U80.14 (VCC), U81.14 (VCC), U82.14 (VCC); also elsewhere on the board
~->Flag_Return: U71.13; also elsewhere on the board
~->Flag_SAVE: U77.1; also elsewhere on the board
~->Flag_SET: U71.12; also elsewhere on the board
~->IP_INC1: U67.13; also elsewhere on the board
~->IP_INC2: U67.2; also elsewhere on the board
~->IP_INC3: U67.1; also elsewhere on the board
~->IP_SAVE: U77.2; also elsewhere on the board
~->IP_SET: U67.12; also elsewhere on the board
~->IV_JMP/END_INT: U76.2; also elsewhere on the board
~->RAM_STORE: U77.5; also elsewhere on the board
~->SP_DEC_INT1: U79.2; also elsewhere on the board
~->SP_DEC_INT2: U79.1; also elsewhere on the board
~->SP_DEC_PUSH: U74.1; also elsewhere on the board
~->SP_INC_POP: U74.2; also elsewhere on the board
~->SP_INC_RET: U73.1; also elsewhere on the board
~->SP_SET: U73.2; also elsewhere on the board
~DEC_ALU: U78.8; also elsewhere on the board
~Fetch_END1: U81.10; also elsewhere on the board
~Fetch_END2: U81.9; also elsewhere on the board
~Fetch_Status: U38.3 (Q), U38.4 (LED); also elsewhere on the board
~Flag_Return->: U72.12; also elsewhere on the board
~Flag_SET->: U70.2; also elsewhere on the board
~Flag_Y: U71.8; also elsewhere on the board
~INC_ALU: U81.11; also elsewhere on the board
~INTERNAL_ALU: U70.3, U70.12, U70.13; also elsewhere on the board
~INTERNAL_A: U70.8; also elsewhere on the board
~IP_A: U76.8; also elsewhere on the board
~IP_INC1->: U65.13; also elsewhere on the board
~IP_INC2->: U65.12; also elsewhere on the board
~IP_INC3->: U65.2, U66.1; also elsewhere on the board
~IP_SAVE->: U76.12; also elsewhere on the board
~IP_SET->: U65.1; also elsewhere on the board
~IP_Y: U76.6; also elsewhere on the board
~MEM_A: U72.6; also elsewhere on the board
~MEM_Y: U77.8; also elsewhere on the board
~RAM_LOAD->: U72.13; also elsewhere on the board
~RAM_STORE->: U71.2; also elsewhere on the board
~SP_A: U80.6, U80.10; also elsewhere on the board
~SP_DEC_INT1->: U78.2; also elsewhere on the board
~SP_DEC_INT2->: U78.1; also elsewhere on the board
~SP_DEC_PUSH->: U75.12; also elsewhere on the board
~SP_INC_POP->: U75.13; also elsewhere on the board
~SP_INC_RET->: U73.13; also elsewhere on the board
~SP_SET->: U73.12, U78.9, U81.13; also elsewhere on the board
~SP_Y: U79.8; also elsewhere on the board

Notes on the sheet:
POP/RET
INCの抑制
DECの抑制
1サイクル分遅らせることでNOPの抑制のタイミングを調整
INT
A BUS 非内部処理
fetch
exe
PUSH

Parts:
U29, U30, U31, U32, U33, U34: State_hold_unit; PinSocket_1x05_P2.54mm_Vertical
U61: CD74HC00; DIP-14_W7.62mm

Connections:
GND: U61.7 (GND); also elsewhere on the board
unnamed: U29.4 (LED), U29.5 (~Q), U30.1 (D)
unnamed: U30.3 (Q), U30.4 (LED), U61.2, U61.13
unnamed: U31.1 (D), U61.3, U61.12
unnamed: U31.4 (LED), U31.5 (~Q), U32.1 (D)
unnamed: U32.3 (Q), U32.4 (LED), U33.1 (D)
unnamed: U33.3 (Q), U33.4 (LED), U34.1 (D)
unnamed: U34.3 (Q), U34.4 (LED)
unnamed: U61.6, U61.9, U61.10
unnamed: U61.4, U61.11
OP5: U61.1; also elsewhere on the board
VCC: U61.14 (VCC); also elsewhere on the board
~->Flag_Return: U32.5 (~Q); also elsewhere on the board
~->SP_INC_RET: U34.5 (~Q), U61.5; also elsewhere on the board
~->SP_SET: U30.5 (~Q); also elsewhere on the board
~EXE_POP: U61.8; also elsewhere on the board
~Flag_Return->: U31.3 (Q); also elsewhere on the board
~POP_FETCH: U29.1 (D); also elsewhere on the board
~SP_INC_RET->: U33.5 (~Q); also elsewhere on the board
~SP_SET->: U29.3 (Q); also elsewhere on the board

Parts:
U15, U16, U17, U18, U19, U20, U21, U22, U23, U24: State_hold_unit; PinSocket_1x05_P2.54mm_Vertical
U55, U56, U57, U58, U59: CD74HC00; DIP-14_W7.62mm

Connections:
END_EXE: U59.6; also elsewhere on the board
EXE_FETCH: U55.1, U55.2; also elsewhere on the board
GND: U55.7 (GND), U56.7 (GND), U57.7 (GND), U58.7 (GND), U59.7 (GND); also elsewhere on the board
unnamed: U15.1 (D), U55.8
unnamed: U15.4 (LED), U15.5 (~Q), U16.1 (D)
unnamed: U16.3 (Q), U16.4 (LED)
unnamed: U17.1 (D), U56.8
unnamed: U18.3 (Q), U18.4 (LED)
unnamed: U19.1 (D), U56.6
unnamed: U19.3 (Q), U19.4 (LED), U57.9, U57.12
unnamed: U20.1 (D), U57.8
unnamed: U20.4 (LED), U20.5 (~Q), U58.2, U58.5
unnamed: U21.1 (D), U58.8
unnamed: U21.3 (Q), U21.4 (LED)
unnamed: U22.1 (D), U58.11
unnamed: U23.1 (D), U59.8
unnamed: U23.4 (LED), U23.5 (~Q), U24.1 (D)
unnamed: U24.3 (Q), U24.4 (LED)
unnamed: U55.3, U55.4
unnamed: U55.10, U55.11, U56.1
unnamed: U55.6, U55.9, U55.13
unnamed: U56.4, U56.10, U56.11
unnamed: U56.3, U56.9, U56.12
unnamed: U57.3, U57.4
unnamed: U57.10, U57.11, U58.12
unnamed: U57.6, U57.13
unnamed: U58.6, U58.9
unnamed: U59.4, U59.10, U59.11
unnamed: U59.3, U59.12
OP4: U58.1; also elsewhere on the board
OP5: U57.1, U57.2; also elsewhere on the board
OP6: U55.12, U59.1; also elsewhere on the board
OP7: U56.13, U57.5, U59.2; also elsewhere on the board
VCC: U55.14 (VCC), U56.14 (VCC), U57.14 (VCC), U58.14 (VCC), U59.14 (VCC); also elsewhere on the board
Y_Flag_sel: U17.4 (LED), U17.5 (~Q), U18.1 (D); also elsewhere on the board
~->Flag_SET: U18.5 (~Q), U56.5; also elsewhere on the board
~->SP_INC_POP: U24.5 (~Q), U59.5; also elsewhere on the board
~Address_Y: U20.3 (Q); also elsewhere on the board
~EXE_POP: U58.10; also elsewhere on the board
~EXE_PUSH: U55.5; also elsewhere on the board
~Flag_SET->: U17.3 (Q); also elsewhere on the board
~INTERNAL_Y: U22.3 (Q), U22.4 (LED), U59.9, U59.13; also elsewhere on the board
~PUSH_EXE: U58.3, U58.4; also elsewhere on the board
~RAM_LOAD->: U21.5 (~Q), U58.13; also elsewhere on the board
~SP_INC_POP->: U23.3 (Q); also elsewhere on the board

Notes on the sheet:
SetFlag
SetAcc
LでRA3
Y Reg制御に対し， 内部処理モード/非内部処理モードの指定を行う．

Schematic: Interrupt.kicad_sch

Parts:
U39, U40, U41, U42, U43, U44, U45, U46, U47, U48: State_hold_unit; PinSocket_1x05_P2.54mm_Vertical
U62: CD74HC00; DIP-14_W7.62mm

Connections:
GND: U62.7 (GND); also elsewhere on the board
INT: U62.1; also elsewhere on the board
INT_EN: U62.2; also elsewhere on the board
INT_START: U62.9, U62.12; also elsewhere on the board
unnamed: U39.1 (D), U62.6
unnamed: U39.3 (Q), U39.4 (LED), U40.1 (D)
unnamed: U40.3 (Q), U40.4 (LED), U41.1 (D)
unnamed: U41.3 (Q), U41.4 (LED), U42.1 (D)
unnamed: U42.3 (Q), U42.4 (LED), U43.1 (D)
unnamed: U43.3 (Q), U43.4 (LED), U44.1 (D)
unnamed: U44.3 (Q), U44.4 (LED), U45.1 (D)
unnamed: U45.3 (Q), U45.4 (LED), U46.1 (D)
unnamed: U46.3 (Q), U46.4 (LED), U47.1 (D)
unnamed: U47.3 (Q), U47.4 (LED), U48.1 (D)
unnamed: U48.3 (Q), U48.4 (LED)
unnamed: U62.5, U62.8
unnamed: U62.3, U62.13
VCC: U62.14 (VCC); also elsewhere on the board
~->Flag_SAVE: U46.5 (~Q); also elsewhere on the board
~->IP_SAVE: U42.5 (~Q); also elsewhere on the board
~->IV_JMP/END_INT: U48.5 (~Q); also elsewhere on the board
~->SP_DEC_INT1: U40.5 (~Q); also elsewhere on the board
~->SP_DEC_INT2: U44.5 (~Q); also elsewhere on the board
~FETCH_INT: U62.10, U62.11; also elsewhere on the board
~Flag_SAVE->: U45.5 (~Q); also elsewhere on the board
~INT_FETCH: U62.4; also elsewhere on the board
~IP_SAVE->: U41.5 (~Q); also elsewhere on the board
~IV_JMP->: U47.5 (~Q); also elsewhere on the board
~SP_DEC_INT1->: U39.5 (~Q); also elsewhere on the board
~SP_DEC_INT2->: U43.5 (~Q); also elsewhere on the board

Notes on the sheet:
Hで割り込み開始
ソフト割込み
ここだけはステート保持を目的としていない 通常のマスタースレーブ型D-FFとして割り込みの検出を行う

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
Board: 2 copper layers, 209.6 x 154.9 mm, 119 parts (0 on the bottom side), 254 nets.

## KiCad design nlp-16a/Hardware/SW_Board/SW_Board.kicad_pcb

Parts:
J1, J2: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J3: USB-PWR
J4, J5: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
RN1: R_Network04; R_Array_SIP5
RN2: R_Network08_US; R_Array_SIP9
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_6.7x11.72mm_W7.62mm_P2.54mm_LowProfile
SW2: SW_DIP_x08; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W7.62mm_P2.54mm_LowProfile

Connections:
DATA0: J1.1, J2.2, RN2.2 (R1), SW2.9
DATA1: J1.3, J2.4, RN2.3 (R2), SW2.10
DATA2: J1.5, J2.6, RN2.4 (R3), SW2.11
DATA3: J1.7, J2.8, RN2.5 (R4), SW2.12
DATA4: J1.9, J2.10, RN2.6 (R5), SW2.13
DATA5: J1.11, J2.12, RN2.7 (R6), SW2.14
DATA6: J1.13, J2.14, RN2.8 (R7), SW2.15
DATA7: J1.15, J2.16, RN2.9 (R8), SW2.16
DATA8: J1.2, RN1.2 (R1), SW1.5
DATA9: J1.4, RN1.3 (R2), SW1.6
DATA10: J1.6, RN1.4 (R3), SW1.7
GND: J3.1 (FG), J3.2 (GND), J3.4 (FG), J4.2, J5.2, RN1.1 (common), RN2.1 (common)
VCC: J1.17, J3.3 (5V), J4.1, J5.1, SW1.1, SW1.2, SW1.3, SW1.4, SW2.1, SW2.2, SW2.3, SW2.4, SW2.5, SW2.6, SW2.7, SW2.8

Notes on the sheet:
接続関係
Ctrlバス
汎用データ 20x2
Power
ALUデータ

Board: 2 copper layers, 70.5 x 40.0 mm, 9 parts (0 on the bottom side), 13 nets.
