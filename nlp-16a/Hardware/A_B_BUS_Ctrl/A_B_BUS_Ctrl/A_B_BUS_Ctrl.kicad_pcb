# Repository cherry-takuan/nlp (continued)

## KiCad design nlp-16a/Hardware/alu_ctrl/alu_ctrl.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28: 0.1u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C29: 100u; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
J1: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J2: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J3, J4, J6, J7: Conn_02x10_Counter_Clockwise; PinHeader_2x10_P2.54mm_Vertical
J5: Conn_02x10_Counter_Clockwise; PinHeader_2x10_P2.54mm_Horizontal
J8, J9, J10: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2, RN3: R_Network08; R_Array_SIP9
U28: CD74HC00; DIP-14_W7.62mm

Connections:
ADD/SUB: D9.2 (A), J10.1, R1.2, R9.2; also elsewhere on the board
ALU_Ctrl1: D10.2 (A), J10.3, R2.2, R10.2; also elsewhere on the board
ALU_Ctrl2: D11.2 (A), J10.5, R3.2, R11.2; also elsewhere on the board
ALU_Ctrl3: D12.2 (A), J10.7, R4.2, R12.2; also elsewhere on the board
ALU_Ctrl4: D13.2 (A), J10.9, R5.2, R13.2; also elsewhere on the board
ALU_Ctrl5: D14.2 (A), J10.11, R6.2, R14.2; also elsewhere on the board
ALU_Ctrl6: D15.2 (A), J10.13, R7.2, R15.2; also elsewhere on the board
ALU_Ctrl7: D16.2 (A), J10.15, R8.2, R16.2; also elsewhere on the board
B_SIGN: J7.5; also elsewhere on the board
C: D20.2 (A), J7.7; also elsewhere on the board
Cin: J6.15; also elsewhere on the board
Ctrl0: D1.2 (A), J5.19; also elsewhere on the board
Ctrl1: D2.2 (A), J5.17; also elsewhere on the board
Ctrl2: D3.2 (A), J5.15; also elsewhere on the board
Ctrl3: D4.2 (A), J5.13; also elsewhere on the board
Ctrl4: D5.2 (A), J5.11; also elsewhere on the board
Ctrl5: D6.2 (A), J5.9; also elsewhere on the board
Ctrl6: D7.2 (A), J5.7; also elsewhere on the board
Ctrl7: D8.2 (A), J5.5; also elsewhere on the board
Ctrl8: J5.3; also elsewhere on the board
Ctrl9: J5.1; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.2, D21.1 (K), H1.1, H2.1, H3.1, H4.1, J1.1, J2.37, J2.39, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J3.18, J3.20, J4.2, J4.4, J4.6, J4.8, J4.10, J4.12, J4.14, J4.16, J4.18, J4.20, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, J5.18, J5.20, J6.1, J6.3, J6.4, J6.13, J7.1, J7.3, J7.13, J8.2, J8.4, J8.6, J8.8, J8.10, J8.12, J8.14, J8.16, J9.2, J9.4, J9.6, J9.8, J9.10, J9.12, J9.14, J9.16, J10.2, J10.4, J10.6, J10.8, J10.10, J10.12, J10.14, J10.16, RN1.1 (common), RN2.1 (common), RN3.1 (common), U28.7 (GND); also elsewhere on the board
Lin: J6.17, U28.8
Lout/A_sign: J7.9, U28.12; also elsewhere on the board
unnamed: D1.1 (K), RN1.2 (R1)
unnamed: D2.1 (K), RN1.3 (R2)
unnamed: D3.1 (K), RN1.4 (R3)
unnamed: D4.1 (K), RN1.5 (R4)
unnamed: D5.1 (K), RN1.6 (R5)
unnamed: D6.1 (K), RN1.7 (R6)
unnamed: D7.1 (K), RN1.8 (R7)
unnamed: D8.1 (K), RN1.9 (R8)
unnamed: D9.1 (K), RN2.2 (R1)
unnamed: D10.1 (K), RN2.3 (R2)
unnamed: D11.1 (K), RN2.4 (R3)
unnamed: D12.1 (K), RN2.5 (R4)
unnamed: D13.1 (K), RN2.6 (R5)
unnamed: D14.1 (K), RN2.7 (R6)
unnamed: D15.1 (K), RN2.8 (R7)
unnamed: D16.1 (K), RN2.9 (R8)
unnamed: D17.1 (K), RN3.2 (R1)
unnamed: D18.1 (K), RN3.3 (R2)
unnamed: D19.1 (K), RN3.4 (R3)
unnamed: D20.1 (K), RN3.5 (R4)
unnamed: D21.2 (A), R17.2
unnamed: J6.6, R8.1
unnamed: J6.7, J7.15
unnamed: J6.8, R7.1
unnamed: J6.9, J7.17
unnamed: J6.10, R6.1
unnamed: J6.12, R5.1
unnamed: J6.14, R4.1
unnamed: J6.16, R3.1
unnamed: J6.18, R2.1
unnamed: J6.19, J7.11
unnamed: J6.20, R1.1
unnamed: J7.6, R16.1
unnamed: J7.8, R15.1
unnamed: J7.10, R14.1
unnamed: J7.12, R13.1
unnamed: J7.14, R12.1
unnamed: J7.16, R11.1
unnamed: J7.18, R10.1
unnamed: J7.20, R9.1
unnamed: U28.3, U28.4, U28.5
unnamed: U28.9, U28.10, U28.11
ROLL: U28.2, U28.13; also elsewhere on the board
Rin: J7.19, U28.6
Rout: J6.11, U28.1
V: D18.2 (A); also elsewhere on the board
VCC: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.1, J1.2, J2.38, J2.40, J7.4, R17.1, U28.14 (VCC); also elsewhere on the board
Y_BUS0: J3.19; also elsewhere on the board
Y_BUS1: J3.17; also elsewhere on the board
Y_BUS2: J3.15; also elsewhere on the board
Y_BUS3: J3.13; also elsewhere on the board
Y_BUS4: J2.23, J3.11, J8.7; also elsewhere on the board
Y_BUS5: J2.21, J3.9, J8.5; also elsewhere on the board
Y_BUS6: J2.19, J3.7, J8.3; also elsewhere on the board
Y_BUS7: J2.17, J3.5, J8.1; also elsewhere on the board
Y_BUS8: J2.15, J4.19, J9.15; also elsewhere on the board
Y_BUS9: J2.13, J4.17, J9.13; also elsewhere on the board
Y_BUS10: J2.11, J4.15, J9.11; also elsewhere on the board
Y_BUS11: J2.9, J4.13, J9.9; also elsewhere on the board
Y_BUS12: J2.7, J4.11, J9.7; also elsewhere on the board
Y_BUS13: J2.5, J4.9, J9.5; also elsewhere on the board
Y_BUS14: J2.3, J4.7, J9.3; also elsewhere on the board
Y_BUS15: D19.2 (A), J2.1, J4.5, J9.1; also elsewhere on the board
Y_Flag_BUS0: J2.31, J8.15; also elsewhere on the board
Y_Flag_BUS1: J2.29, J8.13; also elsewhere on the board
Y_Flag_BUS2: J2.27, J8.11; also elsewhere on the board
Y_Flag_BUS3: J2.25, J8.9; also elsewhere on the board
Y_Flag_sel: J5.4; also elsewhere on the board
Z: D17.2 (A); also elsewhere on the board
carry_flag: J5.2; also elsewhere on the board

Notes on the sheet:
Ctrl0-5 IR 8-13 Ctrl6 IR1 16 Ctrl7 ~ALU_G Ctrl8 ~ALU_MOV Ctrl9 ~ALU_INC
DEBUG PORT
ALU制御バス
Yバス(8bitALUユニットより)
ロール命令
POWER
Y/Flagバス
== ALU Ctrl入力 == IR1の8-13 MOV,JMP キャリーフラグ(with carryな命令用) 動作指定用 ALU_G 動作指定用 MOV 動作指定用 ~INC/DEC == Y/Flagセレクタ == Y/Flag 計12ピン
mode1 mode2 mode3 select_R select_L select_AND_A select_OR/NOT/XOR select_ADD/SUB MSO
ALU基板コントロールバス

Parts:
U19, U20, U21, U22, U23, U24, U25, U26, U27: CD74HC00; DIP-14_W7.62mm

Connections:
ADD/SUB: U24.11; also elsewhere on the board
ALU_Ctrl1: U21.8; also elsewhere on the board
ALU_Ctrl2: U23.8; also elsewhere on the board
ALU_Ctrl3: U20.11; also elsewhere on the board
ALU_Ctrl4: U20.8; also elsewhere on the board
ALU_Ctrl5: U19.11; also elsewhere on the board
ALU_Ctrl6: U19.8; also elsewhere on the board
ALU_Ctrl7: U20.3; also elsewhere on the board
C0: U20.10, U20.12, U22.11
C1: U20.2, U21.1, U22.6, U22.9, U22.10
C2: U19.9, U20.4, U20.5, U20.13, U26.11
C3: U24.1, U26.8
C4: U21.5, U24.12, U27.8
C5: U24.5, U27.6
Cin: U24.8; also elsewhere on the board
Ctrl0: U25.1; also elsewhere on the board
Ctrl1: U25.4; also elsewhere on the board
Ctrl2: U26.1; also elsewhere on the board
Ctrl3: U26.4; also elsewhere on the board
Ctrl4: U27.13; also elsewhere on the board
Ctrl5: U27.2; also elsewhere on the board
Ctrl6: U25.2, U25.5; also elsewhere on the board
Ctrl7: U22.2, U25.10, U26.2, U26.5, U27.1, U27.12; also elsewhere on the board
Ctrl8: U22.5, U23.1, U23.2, U26.13; also elsewhere on the board
Ctrl9: U23.5; also elsewhere on the board
GND: U19.7 (GND), U20.7 (GND), U21.7 (GND), U22.7 (GND), U23.7 (GND), U24.7 (GND), U25.7 (GND), U26.7 (GND), U27.7 (GND); also elsewhere on the board
unnamed: U19.3, U19.4, U19.5
unnamed: U19.6, U19.10, U19.12
unnamed: U21.6, U21.12
unnamed: U21.3, U21.13
unnamed: U22.1, U25.11
unnamed: U22.4, U25.8
unnamed: U23.3, U23.4
unnamed: U23.6, U27.5, U27.9
unnamed: U23.9, U23.10, U23.11
unnamed: U24.6, U24.9
unnamed: U24.3, U24.10
unnamed: U25.6, U25.9
unnamed: U25.3, U25.12, U25.13
unnamed: U26.3, U26.12
unnamed: U27.3, U27.4
unnamed: U27.10, U27.11
ROLL: U21.9, U21.10, U21.11; also elsewhere on the board
VCC: U19.14 (VCC), U20.14 (VCC), U21.14 (VCC), U22.14 (VCC), U23.14 (VCC), U24.14 (VCC), U25.14 (VCC), U26.14 (VCC), U27.14 (VCC); also elsewhere on the board
carry_flag: U24.2; also elsewhere on the board
~C0: U19.1, U20.1, U22.3, U22.12, U22.13, U24.13
~C1: U19.2, U21.4, U22.8, U23.12
~C2: U19.13, U20.6, U20.9, U21.2
~C3: U23.13, U24.4, U26.6, U26.9, U26.10

Notes on the sheet:
74HC00 9
ADD/SUB介入モードに不具合 モード設定が逆通常HでADD/SUBモードのみL MOVモード，通常演算モードに影響を与えない設計にする必要があり →解消 Crtl1デコード不完全→解消 最終版→Ctrl1は反転とする． →非反転に設計変更．下記の「削除」修正
Ctrl0-5 IR 8-13 Ctrl6 ADDRESS_MODE(IR1 15) Ctrl7 ~INTERNAL_MOV Ctrl8 ~INTERNAL_INC Ctrl9 ~INTERNAL_DEC ADDRESS_MODE: アドレッシング時の演算モードに切り替え．演算命令以外でこのモードになる． INTERNAL_MOV: 内部処理での値を移動するときのモード． ADDRESS_MODEより優先される． INTERNAI_INC: 内部処理でインクリメントするときのモード． このモードを使用する際にはINTERNAL_MOVが有効である必要がある． ADDRESS_MODEより優先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
25,22
U1-20:フラグ生成，セレクタ関連 U19以降:ALU制御信号デコーダ

Parts:
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18: CD74HC00; DIP-14_W7.62mm

Connections:
ADD/SUB: U13.1, U13.5; also elsewhere on the board
B_SIGN: U13.2, U13.13; also elsewhere on the board
C: U16.9; also elsewhere on the board
GND: U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.7 (GND), U5.7 (GND), U6.7 (GND), U7.7 (GND), U8.7 (GND), U9.7 (GND), U10.7 (GND), U11.7 (GND), U12.7 (GND), U13.7 (GND), U14.7 (GND), U15.7 (GND), U16.7 (GND), U17.7 (GND), U18.7 (GND); also elsewhere on the board
Lout/A_sign: U14.1, U14.5, U15.2, U15.13; also elsewhere on the board
unnamed: U1.1, U1.11, U16.1
unnamed: U1.2, U1.8
unnamed: U1.3, U1.4, U1.5
unnamed: U1.6, U9.13
unnamed: U2.1, U2.11
unnamed: U2.2, U2.8
unnamed: U2.3, U2.4, U2.5
unnamed: U2.6, U9.12
unnamed: U3.1, U3.11
unnamed: U3.2, U3.8
unnamed: U3.3, U3.4, U3.5
unnamed: U3.6, U9.10
unnamed: U4.1, U4.11
unnamed: U4.2, U4.8
unnamed: U4.3, U4.4, U4.5
unnamed: U5.1, U5.11
unnamed: U5.2, U5.8
unnamed: U5.3, U5.4, U5.5
unnamed: U6.1, U6.11
unnamed: U6.2, U6.8
unnamed: U6.3, U6.4, U6.5
unnamed: U7.1, U7.11
unnamed: U7.2, U7.8
unnamed: U7.3, U7.4, U7.5
unnamed: U8.1, U8.11
unnamed: U8.2, U8.8
unnamed: U8.3, U8.4, U8.5
unnamed: U9.1, U9.2, U9.11
unnamed: U9.3, U9.9
unnamed: U9.4, U9.5, U9.8
unnamed: U10.1, U10.2, U10.11
unnamed: U10.3, U10.9
unnamed: U10.4, U10.5, U10.8
unnamed: U10.6, U11.13
unnamed: U5.6, U10.10
unnamed: U4.6, U10.12
unnamed: U9.6, U10.13
unnamed: U11.1, U11.2, U11.11
unnamed: U11.3, U11.9
unnamed: U11.4, U11.5, U11.8
unnamed: U11.6, U12.13
unnamed: U7.6, U11.10
unnamed: U6.6, U11.12
unnamed: U12.3, U17.2, U17.5, U17.10, U17.13
unnamed: U12.4, U12.8
unnamed: U12.5, U15.8
unnamed: U12.9, U12.10, U14.8
unnamed: U8.6, U12.12
unnamed: U13.6, U13.9
unnamed: U13.8, U14.2, U14.13
unnamed: U13.10, U13.11
unnamed: U13.3, U13.4, U13.12
unnamed: U14.6, U14.9
unnamed: U14.10, U14.11
unnamed: U14.3, U14.4, U14.12
unnamed: U15.6, U15.9
unnamed: U15.10, U15.11
unnamed: U15.3, U15.4, U15.12
unnamed: U16.3, U18.2
unnamed: U16.6, U18.5
unnamed: U16.8, U18.9
unnamed: U16.11, U18.12
unnamed: U17.3, U18.1
unnamed: U17.6, U18.4
unnamed: U17.8, U18.10
unnamed: U17.11, U18.13
V: U12.6, U16.4; also elsewhere on the board
VCC: U1.14 (VCC), U2.14 (VCC), U3.14 (VCC), U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.14 (VCC), U8.14 (VCC), U9.14 (VCC), U10.14 (VCC), U11.14 (VCC), U12.14 (VCC), U13.14 (VCC), U14.14 (VCC), U15.14 (VCC), U16.14 (VCC), U17.14 (VCC), U18.14 (VCC); also elsewhere on the board
Y_BUS0: U8.9, U8.10, U17.9; also elsewhere on the board
Y_BUS1: U8.12, U8.13, U17.4; also elsewhere on the board
Y_BUS2: U7.9, U7.10, U17.12; also elsewhere on the board
Y_BUS3: U7.12, U7.13, U17.1; also elsewhere on the board
Y_BUS4: U6.9, U6.10; also elsewhere on the board
Y_BUS5: U6.12, U6.13; also elsewhere on the board
Y_BUS6: U5.9, U5.10; also elsewhere on the board
Y_BUS7: U5.12, U5.13; also elsewhere on the board
Y_BUS8: U4.9, U4.10; also elsewhere on the board
Y_BUS9: U4.12, U4.13; also elsewhere on the board
Y_BUS10: U3.9, U3.10; also elsewhere on the board
Y_BUS11: U3.12, U3.13; also elsewhere on the board
Y_BUS12: U2.9, U2.10; also elsewhere on the board
Y_BUS13: U2.12, U2.13; also elsewhere on the board
Y_BUS14: U1.9, U1.10; also elsewhere on the board
Y_BUS15: U1.12, U1.13, U15.1, U15.5; also elsewhere on the board
Y_Flag_BUS0: U18.8; also elsewhere on the board
Y_Flag_BUS1: U18.6; also elsewhere on the board
Y_Flag_BUS2: U18.11; also elsewhere on the board
Y_Flag_BUS3: U18.3; also elsewhere on the board
Y_Flag_sel: U12.1, U12.2, U16.2, U16.5, U16.10, U16.13; also elsewhere on the board
Z: U12.11, U16.12; also elsewhere on the board

Notes on the sheet:
74HC00 18
こちらは変更なし
フラグのSVZは反転して負論理で格納． フラグ選択の回路で通常時に反転させることでフラグの動作を正論理で扱えるようにする (Cフラグのみプログラムでの修正が必要だが使っていないため問題ない)
Y/Flagセレクタ
削除 ALU回路で生成． ALU基板 U55D 出力から取得
配線の容易さを優先し，最速の接続ではない
フラグ生成
Lout/A_sign -> U28Dの出力に接続

Board: 2 copper layers, 209.5 x 154.9 mm, 112 parts (0 on the bottom side), 186 nets.
