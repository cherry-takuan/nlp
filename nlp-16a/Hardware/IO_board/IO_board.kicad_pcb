# Repository cherry-takuan/nlp (continued)

## KiCad design nlp-16a/Hardware/BUS_terminator/BUS_terminator.kicad_pcb (continued)

Parts:
D2, D3: LED; LED_D3.0mm
R18, R19: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2: R_Network08; R_Array_SIP9
U1, U2, U3, U4, U5, U6, U7, U8, U11, U12: CD74HC00; DIP-14_W7.62mm
U9, U10: 74HCT541; DIP-20_W7.62mm

Connections:
A_SEL: U11.2, U12.4; also elsewhere on the board
BUS_Correction: U11.5, U11.10; also elsewhere on the board
Data_Correction: U5.2, U5.5, U6.2, U6.5, U7.2, U7.5, U8.2, U8.5, U12.3; also elsewhere on the board
GND: U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.7 (GND), U5.7 (GND), U6.7 (GND), U7.7 (GND), U8.7 (GND), U9.1 (G1), U9.10 (GND), U10.1 (G1), U10.10 (GND), U11.7 (GND), U12.7 (GND); also elsewhere on the board
IN0: U10.9 (A7); also elsewhere on the board
IN1: U10.8 (A6); also elsewhere on the board
IN2: U10.7 (A5); also elsewhere on the board
IN3: U10.6 (A4); also elsewhere on the board
IN4: U10.5 (A3); also elsewhere on the board
IN5: U10.4 (A2); also elsewhere on the board
IN6: U10.3 (A1); also elsewhere on the board
IN7: U10.2 (A0); also elsewhere on the board
IN8: U9.9 (A7); also elsewhere on the board
IN9: U9.8 (A6); also elsewhere on the board
IN10: U9.7 (A5); also elsewhere on the board
IN11: U9.6 (A4); also elsewhere on the board
IN12: U9.5 (A3); also elsewhere on the board
IN13: U9.4 (A2); also elsewhere on the board
IN14: U9.3 (A1); also elsewhere on the board
IN15: U9.2 (A0); also elsewhere on the board
IO_BUS0: RN2.9 (R8), U8.4, U10.11 (Y7); also elsewhere on the board
IO_BUS1: RN2.8 (R7), U8.1, U10.12 (Y6); also elsewhere on the board
IO_BUS2: RN2.7 (R6), U7.4, U10.13 (Y5); also elsewhere on the board
IO_BUS3: RN2.6 (R5), U7.1, U10.14 (Y4); also elsewhere on the board
IO_BUS4: RN2.5 (R4), U6.4, U10.15 (Y3); also elsewhere on the board
IO_BUS5: RN2.4 (R3), U6.1, U10.16 (Y2); also elsewhere on the board
IO_BUS6: RN2.3 (R2), U5.4, U10.17 (Y1); also elsewhere on the board
IO_BUS7: RN2.2 (R1), U5.1, U10.18 (Y0); also elsewhere on the board
IO_BUS8: RN1.9 (R8), U4.4, U9.11 (Y7); also elsewhere on the board
IO_BUS9: RN1.8 (R7), U4.1, U9.12 (Y6); also elsewhere on the board
IO_BUS10: RN1.7 (R6), U3.4, U9.13 (Y5); also elsewhere on the board
IO_BUS11: RN1.6 (R5), U3.1, U9.14 (Y4); also elsewhere on the board
IO_BUS12: RN1.5 (R4), U2.4, U9.15 (Y3); also elsewhere on the board
IO_BUS13: RN1.4 (R3), U2.1, U9.16 (Y2); also elsewhere on the board
IO_BUS14: RN1.3 (R2), U1.4, U9.17 (Y1); also elsewhere on the board
IO_BUS15: RN1.2 (R1), U1.1, U9.18 (Y0); also elsewhere on the board
unnamed: D2.1 (K), U11.3, U11.4, U11.9, U11.12, U11.13, U12.1, U12.2, U12.12
unnamed: D2.2 (A), R18.2
unnamed: D3.1 (K), U9.19 (G2), U10.19 (G2), U12.11
unnamed: D3.2 (A), R19.2
unnamed: U1.2, U1.5, U2.2, U2.5, U3.2, U3.5, U4.2, U4.5, U11.11
unnamed: U1.6, U1.9
unnamed: U1.10, U1.13, U2.10, U2.13, U3.10, U3.13, U4.10, U4.13, U11.6
unnamed: U1.3, U1.12
unnamed: U2.6, U2.9
unnamed: U2.3, U2.12
unnamed: U3.6, U3.9
unnamed: U3.3, U3.12
unnamed: U4.6, U4.9
unnamed: U4.3, U4.12
unnamed: U5.6, U5.9
unnamed: U5.3, U5.12
unnamed: U6.6, U6.9
unnamed: U6.3, U6.12
unnamed: U7.6, U7.9
unnamed: U7.3, U7.12
unnamed: U8.6, U8.9
unnamed: U8.3, U8.12
unnamed: U5.10, U5.13, U6.10, U6.13, U7.10, U7.13, U8.10, U8.13, U11.8
OUT0: U8.8; also elsewhere on the board
OUT1: U8.11; also elsewhere on the board
OUT2: U7.8; also elsewhere on the board
OUT3: U7.11; also elsewhere on the board
OUT4: U6.8; also elsewhere on the board
OUT5: U6.11; also elsewhere on the board
OUT6: U5.8; also elsewhere on the board
OUT7: U5.11; also elsewhere on the board
OUT8: U4.8; also elsewhere on the board
OUT9: U4.11; also elsewhere on the board
OUT10: U3.8; also elsewhere on the board
OUT11: U3.11; also elsewhere on the board
OUT12: U2.8; also elsewhere on the board
OUT13: U2.11; also elsewhere on the board
OUT14: U1.8; also elsewhere on the board
OUT15: U1.11; also elsewhere on the board
RD_CLK: U12.6; also elsewhere on the board
VCC: R18.1, R19.1, RN1.1 (common), RN2.1 (common), U1.14 (VCC), U2.14 (VCC), U3.14 (VCC), U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.14 (VCC), U8.14 (VCC), U9.20 (VCC), U10.20 (VCC), U11.1, U11.14 (VCC), U12.14 (VCC); also elsewhere on the board
WR_CLK: U12.8; also elsewhere on the board
Y_SEL: U12.10, U12.13; also elsewhere on the board
phi1: U12.5; also elsewhere on the board
phi2: U12.9; also elsewhere on the board

Notes on the sheet:
上位bit
A_SEL == LOW && Y_SEL == HIGH -> /OE = LOW
Y BUS

Board: 2 copper layers, 209.6 x 154.9 mm, 78 parts (0 on the bottom side), 166 nets.

## KiCad design nlp-16a/Hardware/Reg/Reg.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C18, C19: C; C_Disc_D7.5mm_W2.5mm_P5.00mm
C17: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D17: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
J1, J2: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Vertical
J3, J4: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J5, J6: Conn_02x16_Odd_Even; PinHeader_2x16_P2.54mm_Vertical
J7: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J8: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R33, R36, R37: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U35, U36: CD74HC00; DIP-14_W7.62mm

Connections:
A_Address0: J2.32, J4.32, J6.32
A_Address1: J2.30, J4.30, J6.30
A_Address2: J2.28, J4.28, J6.28
A_Address3: J2.26, J4.26, J6.26
A_Address4: J2.24, J4.24, J6.24
A_Address5: J2.22, J4.22, J6.22
A_Address6: J2.20, J4.20, J6.20
A_Address7: J2.18, J4.18, J6.18
A_Address8: J2.16, J4.16, J6.16
A_Address9: J2.14, J4.14, J6.14
A_Address10: J2.12, J4.12, J6.12
A_Address11: J2.10, J4.10, J6.10
A_Address12: J2.8, J4.8, J6.8
A_Address13: J2.6, J4.6, J6.6
A_Address14: J2.4, J4.4, J6.4
A_Address15: J2.2, J4.2, J6.2
A_IN0: J4.31; also elsewhere on the board
A_IN1: J4.29; also elsewhere on the board
A_IN2: J4.27; also elsewhere on the board
A_IN3: J4.25; also elsewhere on the board
A_IN4: J4.23; also elsewhere on the board
A_IN5: J4.21; also elsewhere on the board
A_IN6: J4.19; also elsewhere on the board
A_IN7: J4.17; also elsewhere on the board
A_IN8: J4.15; also elsewhere on the board
A_IN9: J4.13; also elsewhere on the board
A_IN10: J4.11; also elsewhere on the board
A_IN11: J4.9; also elsewhere on the board
A_IN12: J4.7; also elsewhere on the board
A_IN13: J4.5; also elsewhere on the board
A_IN14: J4.3; also elsewhere on the board
A_IN15: J4.1; also elsewhere on the board
A_OUT0: R1.2; also elsewhere on the board
A_OUT1: R2.2; also elsewhere on the board
A_OUT2: R3.2; also elsewhere on the board
A_OUT3: R4.2; also elsewhere on the board
A_OUT4: R5.2; also elsewhere on the board
A_OUT5: R6.2; also elsewhere on the board
A_OUT6: R7.2; also elsewhere on the board
A_OUT7: R8.2; also elsewhere on the board
A_OUT8: R9.2; also elsewhere on the board
A_OUT9: R10.2; also elsewhere on the board
A_OUT10: R11.2; also elsewhere on the board
A_OUT11: R12.2; also elsewhere on the board
A_OUT12: R13.2; also elsewhere on the board
A_OUT13: R14.2; also elsewhere on the board
A_OUT14: R15.2; also elsewhere on the board
A_OUT15: R16.2; also elsewhere on the board
A_SEL: J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, J6.13, J6.15, J6.17, J6.19, J6.21, J6.23, J6.25, J6.27, J6.29, J6.31, R37.2; also elsewhere on the board
BUS_Correction_IN: J2.35; also elsewhere on the board
BUS_Correction_OUT: J4.35; also elsewhere on the board
Data_Correction_IN: J4.33; also elsewhere on the board
Data_Correction_OUT: J2.33; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, H1.1, H2.1, H3.1, H4.1, J1.35, J1.37, J1.39, J2.37, J2.39, J3.35, J3.37, J3.39, J4.37, J4.39, J7.1, R33.2, U35.7 (GND), U36.7 (GND); also elsewhere on the board
unnamed: D17.1 (K), R33.1
unnamed: J2.1, R16.1
unnamed: J2.3, R15.1
unnamed: J2.5, R14.1
unnamed: J2.7, R13.1
unnamed: J2.9, R12.1
unnamed: J2.11, R11.1
unnamed: J2.13, R10.1
unnamed: J2.15, R9.1
unnamed: J2.17, R8.1
unnamed: J2.19, R7.1
unnamed: J2.21, R6.1
unnamed: J2.23, R5.1
unnamed: J2.25, R4.1
unnamed: J2.27, R3.1
unnamed: J2.29, R2.1
unnamed: J2.31, R1.1
unnamed: U35.3, U35.12, U35.13
unnamed: U36.3, U36.12, U36.13
Reg_out0: J8.6; also elsewhere on the board
Reg_out1: J8.8; also elsewhere on the board
Reg_out2: J8.10; also elsewhere on the board
Reg_out3: J8.12; also elsewhere on the board
Reg_out4: J8.14; also elsewhere on the board
Reg_out5: J8.16; also elsewhere on the board
Reg_out6: J8.18; also elsewhere on the board
Reg_out7: J8.20; also elsewhere on the board
Reg_out8: J8.5; also elsewhere on the board
Reg_out9: J8.7; also elsewhere on the board
Reg_out10: J8.9; also elsewhere on the board
Reg_out11: J8.11; also elsewhere on the board
Reg_out12: J8.13; also elsewhere on the board
Reg_out13: J8.15; also elsewhere on the board
Reg_out14: J8.17; also elsewhere on the board
Reg_out15: J8.19; also elsewhere on the board
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, D17.2 (A), J1.38, J1.40, J2.38, J2.40, J3.38, J3.40, J4.38, J4.40, J7.2, R36.1, R37.1, U35.2, U35.14 (VCC), U36.2, U36.14 (VCC); also elsewhere on the board
Y_Address0: J1.32, J3.32, J5.32
Y_Address1: J1.30, J3.30, J5.30
Y_Address2: J1.28, J3.28, J5.28
Y_Address3: J1.26, J3.26, J5.26
Y_Address4: J1.24, J3.24, J5.24
Y_Address5: J1.22, J3.22, J5.22
Y_Address6: J1.20, J3.20, J5.20
Y_Address7: J1.18, J3.18, J5.18
Y_Address8: J1.16, J3.16, J5.16
Y_Address9: J1.14, J3.14, J5.14
Y_Address10: J1.12, J3.12, J5.12
Y_Address11: J1.10, J3.10, J5.10
Y_Address12: J1.8, J3.8, J5.8
Y_Address13: J1.6, J3.6, J5.6
Y_Address14: J1.4, J3.4, J5.4
Y_Address15: J1.2, J3.2, J5.2
Y_IN0: J1.31; also elsewhere on the board
Y_IN1: J1.29; also elsewhere on the board
Y_IN2: J1.27; also elsewhere on the board
Y_IN3: J1.25; also elsewhere on the board
Y_IN4: J1.23; also elsewhere on the board
Y_IN5: J1.21; also elsewhere on the board
Y_IN6: J1.19; also elsewhere on the board
Y_IN7: J1.17; also elsewhere on the board
Y_IN8: J1.15; also elsewhere on the board
Y_IN9: J1.13; also elsewhere on the board
Y_IN10: J1.11; also elsewhere on the board
Y_IN11: J1.9; also elsewhere on the board
Y_IN12: J1.7; also elsewhere on the board
Y_IN13: J1.5; also elsewhere on the board
Y_IN14: J1.3; also elsewhere on the board
Y_IN15: J1.1; also elsewhere on the board
Y_OUT0: J3.31; also elsewhere on the board
Y_OUT1: J3.29; also elsewhere on the board
Y_OUT2: J3.27; also elsewhere on the board
Y_OUT3: J3.25; also elsewhere on the board
Y_OUT4: J3.23; also elsewhere on the board
Y_OUT5: J3.21; also elsewhere on the board
Y_OUT6: J3.19; also elsewhere on the board
Y_OUT7: J3.17; also elsewhere on the board
Y_OUT8: J3.15; also elsewhere on the board
Y_OUT9: J3.13; also elsewhere on the board
Y_OUT10: J3.11; also elsewhere on the board
Y_OUT11: J3.9; also elsewhere on the board
Y_OUT12: J3.7; also elsewhere on the board
Y_OUT13: J3.5; also elsewhere on the board
Y_OUT14: J3.3; also elsewhere on the board
Y_OUT15: J3.1; also elsewhere on the board
Y_SEL: J5.1, J5.3, J5.5, J5.7, J5.9, J5.11, J5.13, J5.15, J5.17, J5.19, J5.21, J5.23, J5.25, J5.27, J5.29, J5.31, R36.2; also elsewhere on the board
phi1_in: J1.36, U36.1
phi1_out: J3.36, U36.11
phi2_in: J1.34, U35.1
phi2_out: J3.34, U35.11; also elsewhere on the board
~CLR_in: J1.33; also elsewhere on the board
~CLR_out: J3.33; also elsewhere on the board

Notes on the sheet:
上流側
下流側

Parts:
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2, U3, U4, U5, U6, U7, U8, U35, U36: CD74HC00; DIP-14_W7.62mm

Connections:
CLR: U35.6, U35.9, U35.10, U36.9, U36.10; also elsewhere on the board
GND: U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.7 (GND), U5.7 (GND), U6.7 (GND), U7.7 (GND), U8.7 (GND), U35.7 (GND), U36.7 (GND); also elsewhere on the board
unnamed: U1.2, U1.5, U2.2, U2.5, U3.2, U3.5, U4.2, U4.5, U5.2, U5.5, U6.2, U6.5, U7.2, U7.5, U8.2, U8.5, U36.8
unnamed: U1.6, U1.9, U1.10
unnamed: U1.3, U1.12, U1.13
unnamed: U2.6, U2.9, U2.10
unnamed: U2.3, U2.12, U2.13
unnamed: U3.6, U3.9, U3.10
unnamed: U3.3, U3.12, U3.13
unnamed: U4.6, U4.9, U4.10
unnamed: U4.3, U4.12, U4.13
unnamed: U5.6, U5.9, U5.10
unnamed: U5.3, U5.12, U5.13
unnamed: U6.6, U6.9, U6.10
unnamed: U6.3, U6.12, U6.13
unnamed: U7.6, U7.9, U7.10
unnamed: U7.3, U7.12, U7.13
unnamed: U8.6, U8.9, U8.10
unnamed: U8.3, U8.12, U8.13
VCC: U1.14 (VCC), U2.14 (VCC), U3.14 (VCC), U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.14 (VCC), U8.14 (VCC), U35.5, U35.14 (VCC), U36.14 (VCC); also elsewhere on the board
Y_Data0: R17.1, U8.8; also elsewhere on the board
Y_Data1: R18.1, U8.11; also elsewhere on the board
Y_Data2: R19.1, U7.8; also elsewhere on the board
Y_Data3: R20.1, U7.11; also elsewhere on the board
Y_Data4: R21.1, U6.8; also elsewhere on the board
Y_Data5: R22.1, U6.11; also elsewhere on the board
Y_Data6: R23.1, U5.8; also elsewhere on the board
Y_Data7: R24.1, U5.11; also elsewhere on the board
Y_Data8: R25.1, U4.8; also elsewhere on the board
Y_Data9: R26.1, U4.11; also elsewhere on the board
Y_Data10: R27.1, U3.8; also elsewhere on the board
Y_Data11: R28.1, U3.11; also elsewhere on the board
Y_Data12: R29.1, U2.8; also elsewhere on the board
Y_Data13: R30.1, U2.11; also elsewhere on the board
Y_Data14: R31.1, U1.8; also elsewhere on the board
Y_Data15: R32.1, U1.11; also elsewhere on the board
Y_IN0: JP1.1 (A), U8.4; also elsewhere on the board
Y_IN1: JP2.1 (A), U8.1; also elsewhere on the board
Y_IN2: JP3.1 (A), U7.4; also elsewhere on the board
Y_IN3: JP4.1 (A), U7.1; also elsewhere on the board
Y_IN4: JP5.1 (A), U6.4; also elsewhere on the board
Y_IN5: JP6.1 (A), U6.1; also elsewhere on the board
Y_IN6: JP7.1 (A), U5.4; also elsewhere on the board
Y_IN7: JP8.1 (A), U5.1; also elsewhere on the board
Y_IN8: JP9.1 (A), U4.4; also elsewhere on the board
Y_IN9: JP10.1 (A), U4.1; also elsewhere on the board
Y_IN10: JP11.1 (A), U3.4; also elsewhere on the board
Y_IN11: JP12.1 (A), U3.1; also elsewhere on the board
Y_IN12: JP13.1 (A), U2.4; also elsewhere on the board
Y_IN13: JP14.1 (A), U2.1; also elsewhere on the board
Y_IN14: JP15.1 (A), U1.4; also elsewhere on the board
Y_IN15: JP16.1 (A), U1.1; also elsewhere on the board
Y_OUT0: JP1.2 (B), R17.2; also elsewhere on the board
Y_OUT1: JP2.2 (B), R18.2; also elsewhere on the board
Y_OUT2: JP3.2 (B), R19.2; also elsewhere on the board
Y_OUT3: JP4.2 (B), R20.2; also elsewhere on the board
Y_OUT4: JP5.2 (B), R21.2; also elsewhere on the board
Y_OUT5: JP6.2 (B), R22.2; also elsewhere on the board
Y_OUT6: JP7.2 (B), R23.2; also elsewhere on the board
Y_OUT7: JP8.2 (B), R24.2; also elsewhere on the board
Y_OUT8: JP9.2 (B), R25.2; also elsewhere on the board
Y_OUT9: JP10.2 (B), R26.2; also elsewhere on the board
Y_OUT10: JP11.2 (B), R27.2; also elsewhere on the board
Y_OUT11: JP12.2 (B), R28.2; also elsewhere on the board
Y_OUT12: JP13.2 (B), R29.2; also elsewhere on the board
Y_OUT13: JP14.2 (B), R30.2; also elsewhere on the board
Y_OUT14: JP15.2 (B), R31.2; also elsewhere on the board
Y_OUT15: JP16.2 (B), R32.2; also elsewhere on the board
~CLR_in: U35.4; also elsewhere on the board
~CLR_out: U35.8; also elsewhere on the board
