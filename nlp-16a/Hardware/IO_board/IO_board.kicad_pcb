# Repository cherry-takuan/nlp

File readme.md:

# NLP(NAND Logic Processor)
 現在開発中のNANDのみを用いたCPUのプロジェクトです．
現在以下のバリエーションが存在します  

- NLP-16
- NLP-16A

 NLP-16は本プロジェクトの最初の成果物です．2019年(私が高校2年)の冬に設計を開始し，そこから３年ほどかけ製作しました．  
 [動作(Twitter)](https://twitter.com/cherry_takuan/status/1593374888496021505)  
単独での動作に成功しましたがいくつかの改善点が見つかったため，NLP-16によって得られた知見を基に改良版としてNLP-16Aを現在は開発中です．  
 また，NLP-16Aではキット化を目標に設計，製作しています．

## KiCad design nlp-16a/Hardware/IO_board/IO_board.kicad_pcb

File nlp-16a/Hardware/readme.md:

# ハードウェア
ハードウェアへのリンク。回路/基板データをクリックするとブラウザからアートワークや回路が閲覧できます。kicanvasすごい。ありがとう。

アーキテクチャ，命令セットは以下から。

[アーキテクチャ](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/architecture)
[命令セット](https://github.com/cherry-takuan/nlp/blob/master/nlp-16a/architecture/ISA.pdf)

## NLP-16A本体
***
### 演算装置
ALUはプロセッサ内での演算処理を行うユニットです。NLP-16Aでは8bit ALUを2ユニット使用し16bitの並列演算を行っています。

ALU制御回路回路はALUを操作するための制御信号生成し，また演算結果からフラグを生成する機能を持っています。
***
#### ALU本体
[alu_c](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/alu_c)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2Falu_c)

最新バージョン : v1.2

#### ALU制御
[alu_ctrl](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/alu_ctrl)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2Falu_ctrl)

最新バージョン : v1.1
***
### レジスタファイル
レジスタファイルとは，プロセッサ内で一時的に記憶するレジスタと呼ばれる回路を複数集積したものです。NLP-16Aでは16bitのデータを記憶可能なレジスタを16本持っています。

汎用レジスタは5本で，残りのレジスタは何らかの役割を持ち，単純な記憶以外の動作も行うことがあります。

***
### レジスタ
[Reg](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/Reg)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FReg)

最新バージョン : v1.1

#### アキュムレータ
[Accumulztor](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/Accumulator)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FAccumulator)

最新バージョン : v1.1

#### ALU入力バス(A BUS)制御
[A_BUS_Ctrl](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/A_BUS_Ctrl)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FA_BUS_Ctrl)

最新バージョン : v1.1

#### ALU出力バス(Y BUS)制御
[Y_BUS_Ctrl](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/Y_BUS_Ctrl)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FY_BUS_Ctrl)

最新バージョン : v1.2
***
### 入出力
NLP-16Aは16 bit x 64 kwordの1つの入出力ポートを持っています。
内部的にはレジスタの一つとしてアクセス可能な構造になっています。

主記憶及び外部デバイスとの接続に使用されます。
***
#### 外部バス制御
[Bus_terminator](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/BUS_terminator)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FBUS_terminator)

最新バージョン : v1.1

***
### 制御装置
制御装置では，上記のユニットを入力された命令に従って制御を行います。

***

#### 命令デコーダ
[Instruction_decoder](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/Instruction_decoder)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FInstruction_decoder)

最新バージョン : v1.1

#### ステート保持レジスタ
[State_hold](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/State_hold)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FState_hold)

最新バージョン : v1.0

#### 命令デコーダ グルーロジック
[ID_interface](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/ID_interface)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FID_interface)

最新バージョン : v1.1

***

## 周辺機器

***

### NLP-16A専用デバッガ
基板の自動テストやRAMへのIPLデータ書き込み等で使用。

[debug](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/debug)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2Fdebug)

最新バージョン : v1.1

### マザーボード
プロセッサに周辺機器を接続するためのボード。マザーと言いつつ本体よりかなり小さい。

[IO_board](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/IO_board)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FIO_board)

最新バージョン : v1.1

### RAMボード(デバッガ接続版)
主記憶装置。デバッガから内容を書き換えることが可能で，IPL等の導入に使用できる。

[RAM_board](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/RAM_board)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FRAM_board)

最新バージョン : v1.1

### 通信ボード
RS-232Cを介して様々なデバイスと通信可能。PC，サーマルプリンタ，MSMPインターフェイス等と接続した実績がある。

[RS_232C_board](https://github.com/cherry-takuan/nlp/tree/master/nlp-16a/Hardware/RS_232C_board)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2Fnlp%2Ftree%2Fmaster%2Fnlp-16a%2FHardware%2FRS_232C_board)

最新バージョン : v1.2

### ビデオボード

キャラクタジェネレータ付きの640x480画素のVGA映像出力ボード。
VRAM領域にテキストデータを書き込むと対応した画面位置に文字を表示する機能を持つ。

なお以下のリポジトリは画面に表示こそ可能だが，ハードウェアに一部不具合があるバージョン。今後修正を反映予定(正常に動作するボードは完成済みで反映待ち)

[VGAボード](https://github.com/cherry-takuan/NLP_VGA)

[回路/基板データ](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fcherry-takuan%2FNLP_VGA)

Parts:
C1, C2, C3, C4, C5, C6, C7: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
C8: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D1: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J2: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J3, J4, J5, J6, J7, J8: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
Q1: 2SC1815; TO-92_Inline
R1, R2, R3, R4, R5, R6, R7: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
SW2: SW_DIP_x04; SW_DIP_SPSTx04_Piano_10.8x11.72mm_W7.62mm_P2.54mm
U1: 74HC00; DIP-14_W7.62mm
U2: 74LS08; DIP-14_W7.62mm
U3: 74HC74; DIP-14_W7.62mm
U4: 4040; DIP-16_W7.62mm
X1: CXO_DIP8; Oscillator_DIP-8

Connections:
A_SEL: J1.33, U1.5
Address0: J1.2, J2.1; also elsewhere on the board
Address1: J1.4, J2.3; also elsewhere on the board
Address2: J1.6, J2.5; also elsewhere on the board
Address3: J1.8, J2.7; also elsewhere on the board
Address4: J1.10, J2.9; also elsewhere on the board
Address5: J1.12, J2.11; also elsewhere on the board
Address6: J1.14, J2.13; also elsewhere on the board
Address7: J1.16, J2.15; also elsewhere on the board
Address8: J1.18, J2.17; also elsewhere on the board
Address9: J1.20, J2.19; also elsewhere on the board
Address10: J1.22, J2.21; also elsewhere on the board
Address11: J1.24, J2.23; also elsewhere on the board
Address12: J1.26, J2.25; also elsewhere on the board
Address13: J1.28, J2.27; also elsewhere on the board
Address14: J1.30, J2.29; also elsewhere on the board
Address15: J1.32, J2.31; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, H1.1, H2.1, H3.1, H4.1, J1.37, J1.39, J2.38, J2.40, J3.2, J4.2, J5.2, J6.1, J7.2, J8.2, Q1.1 (E), R2.2, R4.2, R6.2, SW1.2, U2.7 (GND), U2.9, U2.10, U2.12, U2.13, U3.7 (GND), U4.8 (VSS), U4.11 (Reset), X1.4 (GND); also elsewhere on the board
INT: J3.1; also elsewhere on the board
IO_BUS0: J1.1; also elsewhere on the board
IO_BUS1: J1.3; also elsewhere on the board
IO_BUS2: J1.5; also elsewhere on the board
IO_BUS3: J1.7; also elsewhere on the board
IO_BUS4: J1.9; also elsewhere on the board
IO_BUS5: J1.11; also elsewhere on the board
IO_BUS6: J1.13; also elsewhere on the board
IO_BUS7: J1.15; also elsewhere on the board
IO_BUS8: J1.17; also elsewhere on the board
IO_BUS9: J1.19; also elsewhere on the board
IO_BUS10: J1.21; also elsewhere on the board
IO_BUS11: J1.23; also elsewhere on the board
IO_BUS12: J1.25; also elsewhere on the board
IO_BUS13: J1.27; also elsewhere on the board
IO_BUS14: J1.29; also elsewhere on the board
IO_BUS15: J1.31; also elsewhere on the board
unnamed: D1.1 (K), R6.1
unnamed: J4.1, Q1.2 (C), SW1.1
unnamed: J5.1, SW2.1
unnamed: J7.1, R5.2
unnamed: J8.1, R7.2
unnamed: Q1.3 (B), R1.2, R2.1
unnamed: R3.2, R4.1, U4.10 (CLK), X1.5 (OUT)
unnamed: R5.1, U2.3
unnamed: R7.1, U2.6
unnamed: SW2.2, U4.6 (Q2)
unnamed: SW2.3, U4.2 (Q5)
unnamed: SW2.4, U4.1 (Q11)
unnamed: SW2.5, SW2.6, SW2.7, SW2.8, U3.3 (C), U3.11 (C)
unnamed: U2.1, U3.9 (Q)
unnamed: U2.2, U3.5 (Q), U3.12 (D)
unnamed: U2.4, U3.2 (D), U3.8 (~Q)
unnamed: U2.5, U3.6 (~Q)
Y_SEL: J1.35, U1.2
~DEBUG_RS: J2.36, R1.1
~RD_CLK: J1.34; also elsewhere on the board
~RD: U1.6; also elsewhere on the board
~WR_CLK: J1.36; also elsewhere on the board
~WR: U1.3; also elsewhere on the board

Notes on the sheet:
phi1
A_SEL -> RD Y_SEL -> WE
RESET
Ext clk
注:ピンヘッダとピンソケットでフットプリントの左右が違う
8MHz
phi2

Parts:
J9: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
U1: 74HC00; DIP-14_W7.62mm
U5: 74LS21; DIP-14_W7.62mm
U6: 74LS138; DIP-16_W7.62mm
U7: 74LS541; DIP-20_W7.62mm

Connections:
Address0: U7.5 (A3); also elsewhere on the board
Address1: U7.6 (A4); also elsewhere on the board
Address2: U7.7 (A5); also elsewhere on the board
Address3: U7.8 (A6); also elsewhere on the board
Address4: U7.9 (A7); also elsewhere on the board
Address5: U6.1 (A0); also elsewhere on the board
Address6: U6.2 (A1); also elsewhere on the board
Address7: U6.3 (A2); also elsewhere on the board
Address8: U5.9; also elsewhere on the board
Address9: U5.10; also elsewhere on the board
Address10: U5.12; also elsewhere on the board
Address11: U5.13; also elsewhere on the board
Address12: U5.1; also elsewhere on the board
Address13: U5.2; also elsewhere on the board
Address14: U5.4; also elsewhere on the board
Address15: U5.5; also elsewhere on the board
GND: J9.38, J9.40, U1.7 (GND), U5.7 (GND), U6.4 (E1), U6.8 (GND), U7.1 (G1), U7.2 (A0), U7.3 (A1), U7.4 (A2), U7.10 (GND), U7.19 (G2); also elsewhere on the board
INT: J9.31; also elsewhere on the board
IO_BUS0: J9.2; also elsewhere on the board
IO_BUS1: J9.4; also elsewhere on the board
IO_BUS2: J9.6; also elsewhere on the board
IO_BUS3: J9.8; also elsewhere on the board
IO_BUS4: J9.10; also elsewhere on the board
IO_BUS5: J9.12; also elsewhere on the board
IO_BUS6: J9.14; also elsewhere on the board
IO_BUS7: J9.16; also elsewhere on the board
IO_BUS8: J9.18; also elsewhere on the board
IO_BUS9: J9.20; also elsewhere on the board
IO_BUS10: J9.22; also elsewhere on the board
IO_BUS11: J9.24; also elsewhere on the board
IO_BUS12: J9.26; also elsewhere on the board
IO_BUS13: J9.28; also elsewhere on the board
IO_BUS14: J9.30; also elsewhere on the board
IO_BUS15: J9.32; also elsewhere on the board
unnamed: J9.1, U7.15 (Y3)
unnamed: J9.3, U7.14 (Y4)
unnamed: J9.5, U7.13 (Y5)
unnamed: J9.7, U7.12 (Y6)
unnamed: J9.9, U7.11 (Y7)
unnamed: U1.10, U1.11, U6.5 (E2)
unnamed: U1.12, U1.13, U5.8
~RD_CLK: J9.33; also elsewhere on the board
~RD: J9.34; also elsewhere on the board
~WR_CLK: J9.35; also elsewhere on the board
~WR: J9.36; also elsewhere on the board
~dev1: J9.11, U1.9, U5.6, U6.6 (E3)
~dev2: J9.13, U1.8
~dev3: J9.15, U6.15 (O0)
~dev4: J9.17, U6.14 (O1)
~dev5: J9.19, U6.13 (O2)
~dev6: J9.21, U6.12 (O3)
~dev7: J9.23, U6.11 (O4)
~dev8: J9.25, U6.10 (O5)
~dev9: J9.27, U6.9 (O6)
~dev10: J9.29, U6.7 (O7)

Notes on the sheet:
F000 - FEFF
A_SEL -> RD Y_SEL -> WE
0000 - EFFF
I/O port
FF00 - FFFF 0 : FF00 - FF1F 1 : FF20 - FF3F 2 : FF40 - FF5F 3 : FF60 - FF7F 4 : FF80 - FF9F 5 : FFA0 - FFBF 6 : FFC0 - FFDF 7 : FFE0 - FFFF
注:ピンヘッダとピンソケットでフットプリントの左右が違う

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
Board: 2 copper layers, 99.7 x 99.7 mm, 40 parts (0 on the bottom side), 76 nets.

## KiCad design nlp-16a/Hardware/RS_232C_board/RS_232.kicad_pcb

File nlp-16a/readme.md:

# NLP-16A
NLP-16の知見を基に現在製作しているNAND CPU．
スペックを維持したままキット化(あわよくば教育用に)を目標にしている．
## 歴
- 2023年始 次世代機(NLP-16A)の開発の検討
- 2023/03/11 NLP-16の開発を中止．NLP-16によって得られた知見を基に改良版の16Aの開発に移行．
- 2023/03/15 NLP-16A ALU開発開始
- 2023/05/15～ 基板到着．試作開始
- 2023/07/26～ ALU制御基板開発開始
- 2023/08/10～ デバッガ開発開始

## 現在の作業
- [ALUの製作](./Hardware/alu_c)→完了
- ALU制御(回路設計段階)→完了
- [デバッガの製作](./Hardware/debugger)→完了
- Y BUS制御→完了
- A BUS制御→完了
- Acc→完了
- Reg→完了

## 現時点で判明している不良個所
### ALU  
電源のターミナルブロックとICの干渉  
NLP-16と基板形状の不一致  
ALU制御基板-ALU基板間の制御ピンにおいて入力Bの符号ビットが設計から欠落  
デコード回路の軽微な修正
### 命令デコーダ
設計中
### レジスタ，データバス  
設計完了  
Y BUS内部処理モードにAccの追加
### I/O
設計完了  
特になし．

### デバッガ  
設計完了(USB-UART変換は未定)  

## 設計変更点  
- MEMのRegAddressを10から11に変更  
- RegAddress10をRegFに変更(これはまた変更の可能性があるが，変更の範囲は内部モードで使用しない用途に限る)  

## NLP-16との更新  
- PCB化  
- レジスタバスに用いた回路を変更．アクセスの最悪値を約1/3に高速化した  
- 1word命令の増強．演算系命令を中心にアキュムレータを積極的に使用する演算を行う．  
- 割り込み関連命令の増強．割り込み禁止/許可命令，ソフトウェア割り込みの実装を行った．

Parts:
C1, C2, C3, C4, C5, C6: C_Polarized; CP_Radial_D5.0mm_P2.50mm
C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D5, D6: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1, J2: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J3, J5: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
J4: DB9_Female_MountingHoles; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
J6: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J7: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
JP1: Jumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm
Q1: 2SC1815; TO-92_Inline
R1, R2, R3, R4, R5, R6, R7, R8: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_DIP_x08; SW_DIP_SPSTx08_Piano_10.8x21.88mm_W7.62mm_P2.54mm
U1: 74LS08; DIP-14_W7.62mm
U2: 4040; DIP-16_W7.62mm
U3, U10: 4020; DIP-16_W7.62mm
U4, U13: 74HC74; DIP-14_W7.62mm
U5: 74HC04; DIP-14_W7.62mm
U6: 74LS541; DIP-20_W7.62mm
U7: 74HC595; DIP-16_W7.62mm
U8: MAX232; DIP-16_W7.62mm
U9: 74HC00; DIP-14_W7.62mm
U11, U12: 74HC165; DIP-16_W7.62mm
X1: CXO_DIP8; Oscillator_DIP-8

Connections:
Address0: J2.1, U9.4
CLK: SW2.1, SW2.2, SW2.3, SW2.4, SW2.5, SW2.6, SW2.7, SW2.8, U3.10 (CLK), U10.10 (CLK)
CTS: R1.1, U4.9 (Q), U6.2 (A0), U8.10 (T2IN)
GND: C1.2, C5.1, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, H1.1, H2.1, H3.1, H4.1, J2.38, J2.40, J4.0 (PAD), J4.5, J7.1, Q1.1 (E), R2.2, R3.2, U1.7 (GND), U1.12, U1.13, U2.8 (VSS), U2.11 (Reset), U3.8 (VSS), U4.2 (D), U4.7 (GND), U4.12 (D), U5.7 (GND), U5.11, U6.10 (GND), U7.8 (GND), U8.15 (GND), U9.7 (GND), U10.8 (VSS), U11.8 (GND), U11.15 (~CE), U12.4 (D5), U12.8 (GND), U12.15 (~CE), U13.7 (GND), U13.12 (D), X1.4 (GND)
INT: J2.31, J6.2
IO_BUS0: J2.2, U6.18 (Y0), U7.7 (QH), U12.3 (D4)
IO_BUS1: J2.4, U6.17 (Y1), U7.6 (QG), U12.14 (D3)
IO_BUS2: J2.6, U6.16 (Y2), U7.5 (QF), U12.13 (D2)
IO_BUS3: J2.8, U6.15 (Y3), U7.4 (QE), U12.12 (D1)
IO_BUS4: J2.10, U6.14 (Y4), U7.3 (QD), U12.11 (D0)
IO_BUS5: J2.12, U6.13 (Y5), U7.2 (QC), U11.6 (D7)
IO_BUS6: J2.14, U6.12 (Y6), U7.1 (QB), U11.5 (D6)
IO_BUS7: J2.16, U6.11 (Y7), U7.15 (QA), U11.4 (D5)
unnamed: C2.1, U8.1 (C1+)
unnamed: C2.2, U8.3 (C1-)
unnamed: C3.1, U8.4 (C2+)
unnamed: C3.2, U8.5 (C2-)
unnamed: C4.1, U8.2 (VS+)
unnamed: C5.2, U8.6 (VS-)
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R6.2
unnamed: D5.2 (A), R7.2
unnamed: D6.2 (A), R8.2
unnamed: J2.15, SW1.9
unnamed: J2.17, SW1.10
unnamed: J2.19, SW1.11
unnamed: J2.21, SW1.12
unnamed: J2.23, SW1.13
unnamed: J2.25, SW1.14
unnamed: J2.27, SW1.15
unnamed: J2.29, SW1.16
unnamed: J3.1, U8.14 (T1OUT)
unnamed: J3.2, J4.3
unnamed: J3.3, J4.2
unnamed: J3.4, U8.13 (R1IN)
unnamed: J4.1, J4.4, J4.6
unnamed: J4.7, J5.3
unnamed: J4.8, J5.2
unnamed: J5.1, U8.7 (T2OUT)
unnamed: J5.4, U8.8 (R2IN)
unnamed: J6.1, Q1.2 (C)
unnamed: Q1.3 (B), R1.2, R2.1
unnamed: SW2.9, U2.14 (Q9)
unnamed: SW2.10, U2.12 (Q8)
unnamed: SW2.11, U2.13 (Q7)
unnamed: SW2.12, U2.4 (Q6)
unnamed: SW2.13, U2.2 (Q5)
unnamed: SW2.14, U2.3 (Q4)
unnamed: SW2.15, U2.5 (Q3)
unnamed: SW2.16, U2.6 (Q2)
unnamed: U1.1, U3.4 (Q5)
unnamed: U1.2, U3.12 (Q8)
unnamed: U1.3, U1.4
unnamed: U1.5, U3.7 (Q3)
unnamed: U1.6, U5.9
unnamed: U1.8, U9.10, U9.13
unnamed: U1.10, U5.12, U9.5
unnamed: U2.10 (CLK), X1.5 (OUT)
unnamed: U3.5 (Q4), U7.11 (SRCLK)
unnamed: U4.3 (C), U5.2
unnamed: U4.4 (~S), U5.8
unnamed: U5.4, U9.12
unnamed: U5.6, U9.9
unnamed: U10.5 (Q4), U11.2 (CP), U12.2 (CP)
unnamed: U9.2, U10.12 (Q8)
unnamed: U9.1, U10.13 (Q7)
unnamed: U11.9 (Q7), U12.10 (DS)
unnamed: U9.3, U13.10 (~S)
RTS: U6.4 (A2), U8.9 (R2OUT)
Receiving: U3.11 (Reset), U4.5 (Q), U6.5 (A3), U7.12 (RCLK)
UART IN: D6.1 (K), U4.10 (~S), U5.1, U7.14 (SER), U8.12 (R1OUT)
UART OUT: D5.1 (K), U8.11 (T1IN), U12.9 (Q7)
~COMMAND: D2.1 (K), U1.9, U6.1 (G1), U9.6
~EN: SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, U5.13
~RD_CLK: J2.33, JP1.1 (A)
~RD_G: JP1.2 (C), U5.5, U6.19 (G2)
~RD: J2.34, JP1.3 (B)
~Read_EN: D4.1 (K), U4.11 (C), U7.13 (~OE), U9.8
~Send_EN: D3.1 (K), U9.11, U11.1 (~PL), U12.1 (~PL), U13.11 (C)
~WR_CLK: J2.35, U5.3
~busy: U6.3 (A1), U10.11 (Reset), U13.9 (Q)

Notes on the sheet:
RS-232Cレベル変換より
A_SEL -> RD Y_SEL -> WE
送信データ取り込み
シリアル-パラレル変換 受信バッファ バススイッチ
slave
ステート管理
送信回路
RS-232Cレベル変換へ
送信終了
送信開始
STOP
0x00 : DATA 0x01 : COMMAND
スタートビット検出
クロックジェネレータ
start
シリアル-パラレル変換 スタートビット，ストップビット生成
I/Oバス，制御バスへ
シリアルデータ同期用クロック
I/Oバス，制御バスより
Shift CLK
〜受信中フラグ
Vdd Vdd GND D0 | D7 Vdd
注:ピンヘッダとピンソケットでフットプリントの左右が違う
送信中
19200bard
CTS制御
送信クロック
受信回路
master
注:74HC4020でないと動作周波数の定格を超える

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
Board: 2 copper layers, 99.7 x 99.7 mm, 60 parts (1 on the bottom side), 84 nets.
