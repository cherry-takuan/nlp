# Repository cherry-takuan/nlp (continued)

## KiCad design nlp-16a/Hardware/RAM_board/RAM_board.kicad_pcb

Parts:
C1: C_Polarized; CP_Radial_D5.0mm_P2.50mm
C2, C3, C4: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1, D2: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1, J3, J5: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J2, J4: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J6: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
R1, R2, R3: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
U1, U2: TC551001; DIP-32_W15.24mm
U3: 74LS32; DIP-14_W7.62mm

Connections:
Address0: J2.1, J5.6, U1.12 (A0), U2.12 (A0)
Address1: J2.3, J5.8, U1.11 (A1), U2.11 (A1)
Address2: J2.5, J5.10, U1.23 (A10), U2.23 (A10)
Address3: J2.7, J5.12, U1.10 (A2), U2.10 (A2)
Address4: J2.9, J5.14, U1.9 (A3), U2.9 (A3)
Address5: J2.11, J5.16, U1.25 (A11), U2.25 (A11)
Address6: J2.13, J5.18, U1.8 (A4), U2.8 (A4)
Address7: J2.15, J5.20, U1.26 (A9), U2.26 (A9)
Address8: J2.17, J5.5, U1.7 (A5), U2.7 (A5)
Address9: J2.19, J5.7, U1.27 (A8), U2.27 (A8)
Address10: J2.21, J5.9, U1.6 (A6), U2.6 (A6)
Address11: J2.23, J5.11, U1.28 (A13), U2.28 (A13)
Address12: J2.25, J5.13, U1.5 (A7), U2.5 (A7)
Address13: J2.27, J5.15, U1.4 (A12), U2.4 (A12)
Address14: J2.29, J5.17, U1.3 (A14), U2.3 (A14)
Address15: J2.31, J5.19, U1.31 (A15), U2.31 (A15)
GND: C1.2, C2.2, C3.2, C4.2, H1.1, H2.1, H3.1, H4.1, J2.38, J2.40, J4.38, J4.40, J6.1, R2.2, SW1.2, U1.16 (GND), U2.16 (GND), U3.7 (GND), U3.9, U3.10
IO_BUS0: J3.6, J4.2, U1.21 (Q7)
IO_BUS1: J3.8, J4.4, U1.13 (Q0)
IO_BUS2: J3.10, J4.6, U1.20 (Q6)
IO_BUS3: J3.12, J4.8, U1.14 (Q1)
IO_BUS4: J3.14, J4.10, U1.19 (Q5)
IO_BUS5: J3.16, J4.12, U1.15 (Q2)
IO_BUS6: J3.18, J4.14, U1.18 (Q4)
IO_BUS7: J3.20, J4.16, U1.17 (Q3)
IO_BUS8: J3.5, J4.18, U2.21 (Q7)
IO_BUS9: J3.7, J4.20, U2.13 (Q0)
IO_BUS10: J3.9, J4.22, U2.20 (Q6)
IO_BUS11: J3.11, J4.24, U2.14 (Q1)
IO_BUS12: J3.13, J4.26, U2.19 (Q5)
IO_BUS13: J3.15, J4.28, U2.15 (Q2)
IO_BUS14: J3.17, J4.30, U2.18 (Q4)
IO_BUS15: J3.19, J4.32, U2.17 (Q3)
unnamed: D1.1 (K), R2.1
unnamed: D2.1 (K), U3.6
unnamed: D2.2 (A), R3.2
unnamed: R1.2, SW1.1, U1.30 (CE2), U2.30 (CE2)
VCC: C1.1, C2.1, C3.1, C4.1, D1.2 (A), J2.37, J2.39, J4.37, J4.39, J6.2, R1.1, R3.1, U1.2 (A16), U1.32 (VCC), U2.2 (A16), U2.32 (VCC), U3.5, U3.14 (VCC)
~DEBUG_RD: J1.17, J2.33, U3.12
~DEBUG_RS: J1.15, J2.36
~DEBUG_WR: J1.19, J2.35, U3.1
~RD_BUS: J4.34, U3.13
~RD: U1.24 (~OE), U2.24 (~OE), U3.11
~WR_CLK: J4.35, U3.2
~WR: U1.29 (RW), U2.29 (RW), U3.3
~dev1: J4.11, U1.22 (~CS1), U2.22 (~CS1), U3.4

Notes on the sheet:
注:ピンヘッダとピンソケットでフットプリントの左右が違う
A_SEL -> RD Y_SEL -> WE

Board: 2 copper layers, 99.7 x 99.7 mm, 23 parts (0 on the bottom side), 46 nets.

## KiCad design nlp-16a/Hardware/debug/debug.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D1: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Horizontal
J2: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Horizontal
J3: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J4: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Vertical
J5, J6, J7, J8: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J9: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
R1: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2: R_Network08_US; R_Array_SIP9
U1: CH32V003F4P6; SSOP-20_4.4x6.5mm_P0.65mm

Connections:
DATA0: J4.31, J5.19, J6.19, J7.19, RN2.2 (R1), U1.8 (PD0)
DATA1: J4.29, J5.17, J6.17, J7.17, RN2.3 (R2), U1.10 (PC0)
DATA2: J4.27, J5.15, J6.15, J7.15, RN2.4 (R3), U1.6 (PA2)
DATA3: J4.25, J5.13, J6.13, J7.13, RN2.5 (R4), U1.5 (PA1)
DATA4: J4.23, J5.11, J6.11, J7.11, RN2.6 (R5), U1.4 (PD7/NRST)
DATA5: J4.21, J5.9, J6.9, J7.9, RN2.7 (R6), U1.1 (PD4)
DATA6: J4.19, J5.7, J6.7, J7.7, RN2.8 (R7), U1.20 (PD3)
DATA7: J4.17, J5.5, J6.5, J7.5, RN2.9 (R8), U1.19 (PD2)
DATA8: J4.15, J5.3, J6.20, J8.19, RN1.9 (R8), U1.17 (PC7)
DATA9: J4.13, J5.1, J6.18, J8.17, RN1.8 (R7), U1.16 (PC6)
DATA10: J4.11, J5.2, J6.16, J8.15, RN1.7 (R6), U1.15 (PC5)
DATA11: J4.9, J5.4, J6.14, J8.13, RN1.6 (R5), U1.14 (PC4)
DATA12: J4.7, J5.6, J6.12, J8.11, RN1.5 (R4), U1.13 (PC3)
DATA13: J4.5, J5.8, J6.10, J8.9, RN1.4 (R3), U1.12 (PC2)
DATA14: J4.3, J5.10, J6.8, J8.7, RN1.3 (R2), U1.11 (PC1)
GND: C1.2, C2.2, H1.1, H2.1, H3.1, H4.1, J1.1, J2.1, J3.5, R1.2, U1.7 (VSS)
unnamed: D1.1 (K), R1.1
unnamed: J1.5, J2.5, J9.1
RX: J1.4, J3.4, R2.1, U1.3 (PD6/URX)
SWDIO: J3.3, J4.1, J5.12, J6.6, J8.5, RN1.2 (R1), U1.18 (PD1/SWIO)
TX: J2.4, J3.2, J9.2, U1.2 (PD5/UTX)
VDD: C1.1, C2.1, D1.2 (A), J1.3, J2.3, J3.9, R2.2, RN1.1 (common), RN2.1 (common), U1.9 (VDD)

Notes on the sheet:
RTS →RX ←TX VCC CTS GND
←デイジーチェーン 方向
ALUデータ
マスター側
SWCLK SWDIO GND 3V3 5V
WCH-Link E
接続関係
SWIOは15番目に持っていきたい その他はいい感じに配線
RX TX GND 3V3 5V
スレーブ側
汎用データ 20x2
UART → UART ← VDD VSS
RTS TX→ ←RX VCC CTS GND
Ctrlバス
汎用データ 10x2
デバッガ制御部
→ UART ← UART VDD VSS

Board: 2 copper layers, 87.6 x 61.6 mm, 21 parts (0 on the bottom side), 22 nets.

## KiCad design nlp-16a/Hardware/ID_interface/ID_interface.kicad_pcb

Notes on the sheet:
3word 命令検出 レジスタMUX(統合) ・レジスタMUX 1 ・レジスタMUX 2 ブランチデコーダ パルスシード生成
3Unit
4Unit
8Unit

Parts:
U23, U24: CD74HC00; DIP-14_W7.62mm

Connections:
GND: U23.7 (GND), U24.7 (GND); also elsewhere on the board
INT: U24.8, U24.13; also elsewhere on the board
unnamed: U23.6, U23.9
unnamed: U23.10, U23.11, U24.1
unnamed: U23.3, U23.4, U23.12
unnamed: U23.8, U23.13
unnamed: U24.6, U24.9
unnamed: U24.10, U24.11
unnamed: U24.3, U24.4, U24.12
VCC: U23.14 (VCC), U24.14 (VCC); also elsewhere on the board
phi1_2: U24.2, U24.5; also elsewhere on the board
phi2_2: U23.2, U23.5; also elsewhere on the board
~INT_INPUT: U23.1; also elsewhere on the board

Parts:
U15, U16, U17, U18, U19, U20, U21, U22, U29: CD74HC00; DIP-14_W7.62mm

Connections:
Fetch_Status: U29.2, U29.5; also elsewhere on the board
Flag_C: U21.13; also elsewhere on the board
Flag_S: U20.2; also elsewhere on the board
Flag_V: U21.2; also elsewhere on the board
Flag_Z: U20.13; also elsewhere on the board
Flag_mode0: U19.1, U19.5; also elsewhere on the board
Flag_mode1: U15.2, U17.1, U22.4, U22.5; also elsewhere on the board
Flag_mode2: U15.1, U16.1, U22.1, U22.2; also elsewhere on the board
Flag_mode3: U15.5, U16.5, U17.5, U18.5; also elsewhere on the board
GND: U15.7 (GND), U16.7 (GND), U17.7 (GND), U18.7 (GND), U19.7 (GND), U20.7 (GND), U21.7 (GND), U22.7 (GND), U22.9, U22.10, U29.7 (GND); also elsewhere on the board
NOP: U29.8, U29.13; also elsewhere on the board
unnamed: U15.8, U20.1
unnamed: U15.6, U15.9, U15.10
unnamed: U15.4, U15.11
unnamed: U15.3, U15.12, U15.13
unnamed: U16.2, U18.2, U22.6
unnamed: U16.8, U20.12
unnamed: U16.6, U16.9, U16.10
unnamed: U16.4, U16.11
unnamed: U16.3, U16.12, U16.13
unnamed: U17.2, U18.1, U22.3
unnamed: U17.8, U21.1
unnamed: U17.6, U17.9, U17.10
unnamed: U17.4, U17.11
unnamed: U17.3, U17.12, U17.13
unnamed: U18.8, U21.12
unnamed: U18.6, U18.9, U18.10
unnamed: U18.4, U18.11
unnamed: U18.3, U18.12, U18.13
unnamed: U19.6, U19.9
unnamed: U19.8, U29.1
unnamed: U19.10, U19.11
unnamed: U19.3, U19.4, U19.12
unnamed: U19.2, U19.13, U22.11
unnamed: U20.3, U20.4
unnamed: U20.8, U22.12
unnamed: U20.6, U20.9, U20.10
unnamed: U20.5, U20.11
unnamed: U21.3, U21.4
unnamed: U21.8, U22.13
unnamed: U21.6, U21.9, U21.10
unnamed: U21.5, U21.11
unnamed: U29.6, U29.9
unnamed: U29.10, U29.11
unnamed: U29.3, U29.4, U29.12
VCC: U15.14 (VCC), U16.14 (VCC), U17.14 (VCC), U18.14 (VCC), U19.14 (VCC), U20.14 (VCC), U21.14 (VCC), U22.14 (VCC), U29.14 (VCC); also elsewhere on the board

Notes on the sheet:
S 0b11
Z 0b01
C 0b00
8Unit
V 0b10

Parts:
U11, U12, U13, U14: CD74HC00; DIP-14_W7.62mm

Connections:
3word: U14.8; also elsewhere on the board
GND: U11.7 (GND), U12.4, U12.5, U12.7 (GND), U13.7 (GND), U14.7 (GND); also elsewhere on the board
unnamed: U11.3, U11.4
unnamed: U11.8, U12.9
unnamed: U11.6, U11.9, U11.10
unnamed: U11.5, U11.11
unnamed: U12.8, U14.10
unnamed: U12.10, U12.11
unnamed: U12.3, U12.12, U12.13
unnamed: U13.3, U13.4
unnamed: U13.8, U14.4
unnamed: U13.6, U13.9, U13.10
unnamed: U13.5, U13.11
unnamed: U14.6, U14.9
unnamed: U14.5, U14.11
unnamed: U14.3, U14.12, U14.13
RA2_0: U12.2; also elsewhere on the board
RA2_1: U12.1; also elsewhere on the board
RA2_2: U11.12, U11.13; also elsewhere on the board
RA2_3: U11.1, U11.2; also elsewhere on the board
RA3_0: U14.2; also elsewhere on the board
RA3_1: U14.1; also elsewhere on the board
RA3_2: U13.12, U13.13; also elsewhere on the board
RA3_3: U13.1, U13.2; also elsewhere on the board
VCC: U11.14 (VCC), U12.14 (VCC), U13.14 (VCC), U14.14 (VCC); also elsewhere on the board

Notes on the sheet:
IR3を1 0 0 0 にすればもっとゲート数を減らせる． ただその場合使用ゲート数が13，つまり4n+1個になり都合が悪いので 0 0 1 1で良い
0 0 1 1をRA1，RA2それぞれで検出 重要:IR3のIDを変更

Parts:
U4, U5, U6, U7, U8, U9, U10: CD74HC00; DIP-14_W7.62mm

Connections:
A_BUS_Addr0: U9.8; also elsewhere on the board
A_BUS_Addr1: U9.11; also elsewhere on the board
A_BUS_Addr2: U8.8; also elsewhere on the board
A_BUS_Addr3: U8.11; also elsewhere on the board
BUS_A/~B: U4.13, U5.13, U6.13, U7.13, U10.1, U10.2; also elsewhere on the board
BUS_A/~Y: U4.10, U5.10, U6.10, U7.10, U10.12, U10.13; also elsewhere on the board
GND: U4.7 (GND), U5.7 (GND), U6.7 (GND), U7.7 (GND), U8.7 (GND), U9.7 (GND), U10.4, U10.5, U10.7 (GND); also elsewhere on the board
unnamed: U4.3, U4.4
unnamed: U4.6, U4.9
unnamed: U4.8, U8.13
unnamed: U4.5, U4.11
unnamed: U5.3, U5.4
unnamed: U5.6, U5.9
unnamed: U5.8, U8.10
unnamed: U5.5, U5.11
unnamed: U6.3, U6.4
unnamed: U6.6, U6.9
unnamed: U6.8, U9.13
unnamed: U6.5, U6.11
unnamed: U7.3, U7.4
unnamed: U7.6, U7.9
unnamed: U7.8, U9.10
unnamed: U7.5, U7.11
unnamed: U8.6, U8.9
unnamed: U8.3, U8.12
unnamed: U9.6, U9.9
unnamed: U9.3, U9.12
unnamed: U4.2, U5.2, U6.2, U7.2, U10.3
unnamed: U8.2, U8.5, U9.2, U9.5, U10.11
RA1_0: U9.4; also elsewhere on the board
RA1_1: U9.1; also elsewhere on the board
RA1_2: U8.4; also elsewhere on the board
RA1_3: U8.1; also elsewhere on the board
RA2_0: U7.12; also elsewhere on the board
RA2_1: U6.12; also elsewhere on the board
RA2_2: U5.12; also elsewhere on the board
RA2_3: U4.12; also elsewhere on the board
RA3_0: U7.1; also elsewhere on the board
RA3_1: U6.1; also elsewhere on the board
RA3_2: U5.1; also elsewhere on the board
RA3_3: U4.1; also elsewhere on the board
VCC: U4.14 (VCC), U5.14 (VCC), U6.14 (VCC), U7.14 (VCC), U8.14 (VCC), U9.14 (VCC), U10.14 (VCC); also elsewhere on the board

Notes on the sheet:
3Unit

Parts:
U1, U2, U3: CD74HC00; DIP-14_W7.62mm

Connections:
GND: U1.7 (GND), U1.12, U1.13, U2.7 (GND), U3.7 (GND); also elsewhere on the board
unnamed: U1.1, U1.6, U1.9
unnamed: U1.3, U1.4
unnamed: U1.8, U2.2
unnamed: U2.6, U2.9
unnamed: U2.10, U2.11
unnamed: U2.3, U2.4, U2.12
unnamed: U2.8, U2.13, U3.2
unnamed: U3.6, U3.9
unnamed: U3.10, U3.11
unnamed: U3.3, U3.4, U3.12
VCC: U1.14 (VCC), U2.14 (VCC), U3.14 (VCC); also elsewhere on the board
phi1_2: U3.1, U3.5; also elsewhere on the board
phi2_2: U2.1, U2.5; also elsewhere on the board
~RS: U1.5, U1.10; also elsewhere on the board
~Seed_pluse: U1.2, U3.8, U3.13; also elsewhere on the board
