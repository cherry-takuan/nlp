# Repository cherry-takuan/nlp (continued)

## KiCad design nlp-16a/Hardware/ID_interface/ID_interface.kicad_pcb (continued)

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
C23: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
J1, J5, J6, J7, J8: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J2: Conn_02x10_Counter_Clockwise; PinHeader_2x10_P2.54mm_Horizontal
J3, J4, J9, J10, J11: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Horizontal
R1, R2, R3, R4, R5: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1: R_Network08_Split; R_Array_SIP9
U10, U25, U26, U27, U28, U30: CD74HC00; DIP-14_W7.62mm

Connections:
3word: D4.2 (A), J4.8; also elsewhere on the board
A_BUS_Addr0: J3.12; also elsewhere on the board
A_BUS_Addr1: J3.10; also elsewhere on the board
A_BUS_Addr2: J3.8; also elsewhere on the board
A_BUS_Addr3: J3.6; also elsewhere on the board
BUS_A/~B: D11.2 (A), J4.9; also elsewhere on the board
BUS_A/~Y: D10.2 (A), J4.7; also elsewhere on the board
Fetch_Status: D7.2 (A), J4.11; also elsewhere on the board
Flag_C: J2.2, J11.6; also elsewhere on the board
Flag_S: J11.12; also elsewhere on the board
Flag_V: J11.8; also elsewhere on the board
Flag_Z: J11.10; also elsewhere on the board
Flag_mode0: J10.14; also elsewhere on the board
Flag_mode1: J10.16; also elsewhere on the board
Flag_mode2: J10.18; also elsewhere on the board
Flag_mode3: J10.20; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.2, H1.1, H2.1, H3.1, H4.1, J1.1, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J3.2, J3.4, J4.2, J4.4, J5.1, J6.1, J7.1, J8.1, R1.2, R2.2, R3.2, RN1.1 (R1.1), U10.7 (GND), U25.7 (GND), U26.7 (GND), U27.7 (GND), U28.7 (GND), U30.1, U30.2, U30.4, U30.5, U30.7 (GND); also elsewhere on the board
INT: D6.2 (A), J4.10; also elsewhere on the board
INT_EN: D5.2 (A), J4.5
NOP: D9.2 (A), J4.16; also elsewhere on the board
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D2.2 (A), U25.11
unnamed: D3.1 (K), R3.1
unnamed: D3.2 (A), U26.11
unnamed: D4.1 (K), RN1.9 (R8.2)
unnamed: D5.1 (K), RN1.8 (R7.2)
unnamed: D6.1 (K), RN1.7 (R6.2)
unnamed: D7.1 (K), RN1.6 (R5.2)
unnamed: D8.1 (K), RN1.5 (R4.2)
unnamed: D9.1 (K), RN1.4 (R3.2)
unnamed: D10.1 (K), RN1.3 (R2.2)
unnamed: D11.1 (K), RN1.2 (R1.2)
unnamed: U25.3, U25.4, U25.5, U25.9, U25.10, U25.12, U25.13
unnamed: U26.3, U26.4, U26.5, U26.9, U26.10, U26.12, U26.13
unnamed: U30.9, U30.10, U30.11
OP0: J2.9, J3.19, J10.5
OP1: J2.11, J3.17, J10.7
OP2: J2.13, J3.15, J10.9
OP3: J2.15, J3.13, J10.11
OP4: J2.17, J3.11, J10.13
OP5: J2.19, J3.9, J10.15
OP6: J3.7, J10.17
OP7: J3.5, J10.19, U10.9, U10.10
RA1_0: J3.20, J10.6; also elsewhere on the board
RA1_1: J3.18, J10.8; also elsewhere on the board
RA1_2: J3.16, J10.10; also elsewhere on the board
RA1_3: J3.14, J10.12; also elsewhere on the board
RA2_0: J9.13; also elsewhere on the board
RA2_1: J9.15; also elsewhere on the board
RA2_2: J9.17; also elsewhere on the board
RA2_3: J9.19; also elsewhere on the board
RA3_0: J9.5; also elsewhere on the board
RA3_1: J9.7; also elsewhere on the board
RA3_2: J9.9; also elsewhere on the board
RA3_3: J9.11; also elsewhere on the board
VCC: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, D1.2 (A), J1.2, R4.2, R5.2, U10.14 (VCC), U25.14 (VCC), U26.14 (VCC), U27.14 (VCC), U28.14 (VCC), U30.13, U30.14 (VCC); also elsewhere on the board
Y_Flag_sel: J2.4, J4.13
phi1: J5.2, U25.1, U25.2
phi1_1: J4.20, U25.8
phi1_2: U25.6; also elsewhere on the board
phi2: J6.2, U26.1, U26.2
phi2_1: J4.18, U26.8
phi2_2: U26.6; also elsewhere on the board
~Addr_ALU: J2.7, U10.8
~DEC_ALU: J2.1, J4.15
~INC_ALU: J2.3, J4.17
~INTERNAL_ALU: J2.5, J4.19
~INT_INPUT: J8.2, R5.1; also elsewhere on the board
~RS_INPUT: J7.2, R4.1, U30.12
~RS: D8.2 (A), J4.14, U30.8; also elsewhere on the board
~Seed_pluse: J4.12; also elsewhere on the board

Notes on the sheet:
Ctrl0-5 IR 8-13 Ctrl6 ADDRESS_MODE(IR1 15) Ctrl7 ~INTERNAL_MOV Ctrl8 ~INTERNAL_INC Ctrl9 ~INTERNAL_DEC ADDRESS_MODE: アドレッシング時の演算モードに切り替え．演算命令以外でこのモードになる． INTERNAL_MOV: 内部処理での値を移動するときのモード． ADDRESS_MODEより優先される． INTERNAI_INC: 内部処理でインクリメントするときのモード． このモードを使用する際にはINTERNAL_MOVが有効である必要がある． ADDRESS_MODEより優先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
IR2
Flag
LでYが出力
Power
== ALU Ctrl入力 == IR1の8-13 MOV,JMP キャリーフラグ(with carryな命令用) 動作指定用 ALU_G 動作指定用 MOV 動作指定用 ~INC/DEC == Y/Flagセレクタ == Y/Flag 計12ピン
IR1
Reg RD -IV -MEM -IP -SP WR -IR1 -IR2 -IR3 -Acc -Flag -MEM -Address -IP -SP Ctrl -Internal 変更↓ A BUS 4本 Y BUS 4本
ALU -Internal -INC -DEC -Address -Y/F
v1.1以上
etc -3word -NOP -INT -Fetch -RS -BUS Dir -BUS A,B -Seed_pluse CLK -phi1 -phi2
Operand -OP7 -OP6 -OP5 -OP4 -OP1 -OP0
Y BUS
ALU制御バス

Board: 2 copper layers, 209.6 x 154.9 mm, 85 parts (0 on the bottom side), 159 nets.

## KiCad design nlp-16a/Hardware/BUS_terminator/BUS_terminator.kicad_pcb

Parts:
RN3, RN4: R_Network08; R_Array_SIP9
U21, U22: 74HCT541; DIP-20_W7.62mm
U25: CD74HC00; DIP-14_W7.62mm

Connections:
A_SEL: U25.12; also elsewhere on the board
Address_in0: U22.9 (A7); also elsewhere on the board
Address_in1: U22.7 (A5); also elsewhere on the board
Address_in2: U22.5 (A3); also elsewhere on the board
Address_in3: U22.3 (A1); also elsewhere on the board
Address_in4: U21.9 (A7); also elsewhere on the board
Address_in5: U21.7 (A5); also elsewhere on the board
Address_in6: U21.5 (A3); also elsewhere on the board
Address_in7: U21.3 (A1); also elsewhere on the board
Address_in8: U22.8 (A6); also elsewhere on the board
Address_in9: U22.6 (A4); also elsewhere on the board
Address_in10: U22.4 (A2); also elsewhere on the board
Address_in11: U22.2 (A0); also elsewhere on the board
Address_in12: U21.8 (A6); also elsewhere on the board
Address_in13: U21.6 (A4); also elsewhere on the board
Address_in14: U21.4 (A2); also elsewhere on the board
Address_in15: U21.2 (A0); also elsewhere on the board
Address_out0: RN4.9 (R8), U22.11 (Y7); also elsewhere on the board
Address_out1: RN4.7 (R6), U22.13 (Y5); also elsewhere on the board
Address_out2: RN4.5 (R4), U22.15 (Y3); also elsewhere on the board
Address_out3: RN4.3 (R2), U22.17 (Y1); also elsewhere on the board
Address_out4: RN3.9 (R8), U21.11 (Y7); also elsewhere on the board
Address_out5: RN3.7 (R6), U21.13 (Y5); also elsewhere on the board
Address_out6: RN3.5 (R4), U21.15 (Y3); also elsewhere on the board
Address_out7: RN3.3 (R2), U21.17 (Y1); also elsewhere on the board
Address_out8: RN4.8 (R7), U22.12 (Y6); also elsewhere on the board
Address_out9: RN4.6 (R5), U22.14 (Y4); also elsewhere on the board
Address_out10: RN4.4 (R3), U22.16 (Y2); also elsewhere on the board
Address_out11: RN4.2 (R1), U22.18 (Y0); also elsewhere on the board
Address_out12: RN3.8 (R7), U21.12 (Y6); also elsewhere on the board
Address_out13: RN3.6 (R5), U21.14 (Y4); also elsewhere on the board
Address_out14: RN3.4 (R3), U21.16 (Y2); also elsewhere on the board
Address_out15: RN3.2 (R1), U21.18 (Y0); also elsewhere on the board
GND: U21.10 (GND), U21.19 (G2), U22.10 (GND), U22.19 (G2), U25.7 (GND); also elsewhere on the board
unnamed: U21.1 (G1), U22.1 (G1), U25.8
unnamed: U25.3, U25.4
unnamed: U25.6, U25.9, U25.10
unnamed: U25.5, U25.11
VCC: RN3.1 (common), RN4.1 (common), U21.20 (VCC), U22.20 (VCC), U25.1, U25.13, U25.14 (VCC); also elsewhere on the board
Y_SEL: U25.2; also elsewhere on the board

Parts:
C1, C2, C3, C4, C5, C6, C7, C17: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
C8: C_Polarized; CP_Radial_D5.0mm_P2.50mm
D1: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
J1, J2, J3: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J4: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Horizontal
J5: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J6, J7: Conn_02x16_Odd_Even; PinHeader_2x16_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
A_SEL: J3.33, J7.1, J7.3, J7.5, J7.7, J7.9, J7.11, J7.13, J7.15, J7.17, J7.19, J7.21, J7.23, J7.25, J7.27, J7.29, J7.31; also elsewhere on the board
Address_in0: J4.6; also elsewhere on the board
Address_in1: J4.8; also elsewhere on the board
Address_in2: J4.10; also elsewhere on the board
Address_in3: J4.12; also elsewhere on the board
Address_in4: J4.14; also elsewhere on the board
Address_in5: J4.16; also elsewhere on the board
Address_in6: J4.18; also elsewhere on the board
Address_in7: J4.20; also elsewhere on the board
Address_in8: J4.5; also elsewhere on the board
Address_in9: J4.7; also elsewhere on the board
Address_in10: J4.9; also elsewhere on the board
Address_in11: J4.11; also elsewhere on the board
Address_in12: J4.13; also elsewhere on the board
Address_in13: J4.15; also elsewhere on the board
Address_in14: J4.17; also elsewhere on the board
Address_in15: J4.19; also elsewhere on the board
Address_out0: J3.2; also elsewhere on the board
Address_out1: J3.4; also elsewhere on the board
Address_out2: J3.6; also elsewhere on the board
Address_out3: J3.8; also elsewhere on the board
Address_out4: J3.10; also elsewhere on the board
Address_out5: J3.12; also elsewhere on the board
Address_out6: J3.14; also elsewhere on the board
Address_out7: J3.16; also elsewhere on the board
Address_out8: J3.18; also elsewhere on the board
Address_out9: J3.20; also elsewhere on the board
Address_out10: J3.22; also elsewhere on the board
Address_out11: J3.24; also elsewhere on the board
Address_out12: J3.26; also elsewhere on the board
Address_out13: J3.28; also elsewhere on the board
Address_out14: J3.30; also elsewhere on the board
Address_out15: J3.32; also elsewhere on the board
BUS_Correction: J2.35; also elsewhere on the board
Data_Correction: J2.33; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C17.2, H1.1, H2.1, H3.1, H4.1, J1.35, J1.37, J1.39, J2.37, J2.39, J3.37, J3.39, J5.1, R17.2; also elsewhere on the board
IN0: J1.31; also elsewhere on the board
IN1: J1.29; also elsewhere on the board
IN2: J1.27; also elsewhere on the board
IN3: J1.25; also elsewhere on the board
IN4: J1.23; also elsewhere on the board
IN5: J1.21; also elsewhere on the board
IN6: J1.19; also elsewhere on the board
IN7: J1.17; also elsewhere on the board
IN8: J1.15; also elsewhere on the board
IN9: J1.13; also elsewhere on the board
IN10: J1.11; also elsewhere on the board
IN11: J1.9; also elsewhere on the board
IN12: J1.7; also elsewhere on the board
IN13: J1.5; also elsewhere on the board
IN14: J1.3; also elsewhere on the board
IN15: J1.1; also elsewhere on the board
IO_BUS0: J3.1; also elsewhere on the board
IO_BUS1: J3.3; also elsewhere on the board
IO_BUS2: J3.5; also elsewhere on the board
IO_BUS3: J3.7; also elsewhere on the board
IO_BUS4: J3.9; also elsewhere on the board
IO_BUS5: J3.11; also elsewhere on the board
IO_BUS6: J3.13; also elsewhere on the board
IO_BUS7: J3.15; also elsewhere on the board
IO_BUS8: J3.17; also elsewhere on the board
IO_BUS9: J3.19; also elsewhere on the board
IO_BUS10: J3.21; also elsewhere on the board
IO_BUS11: J3.23; also elsewhere on the board
IO_BUS12: J3.25; also elsewhere on the board
IO_BUS13: J3.27; also elsewhere on the board
IO_BUS14: J3.29; also elsewhere on the board
IO_BUS15: J3.31; also elsewhere on the board
unnamed: D1.1 (K), R17.1
unnamed: J1.2, J6.2
unnamed: J1.4, J6.4
unnamed: J1.6, J6.6
unnamed: J1.8, J6.8
unnamed: J1.10, J6.10
unnamed: J1.12, J6.12
unnamed: J1.14, J6.14
unnamed: J1.16, J6.16
unnamed: J1.18, J6.18
unnamed: J1.20, J6.20
unnamed: J1.22, J6.22
unnamed: J1.24, J6.24
unnamed: J1.26, J6.26
unnamed: J1.28, J6.28
unnamed: J1.30, J6.30
unnamed: J1.32, J6.32
unnamed: J2.1, R16.1
unnamed: J2.2, J7.2
unnamed: J2.3, R15.1
unnamed: J2.4, J7.4
unnamed: J2.5, R14.1
unnamed: J2.6, J7.6
unnamed: J2.7, R13.1
unnamed: J2.8, J7.8
unnamed: J2.9, R12.1
unnamed: J2.10, J7.10
unnamed: J2.11, R11.1
unnamed: J2.12, J7.12
unnamed: J2.13, R10.1
unnamed: J2.14, J7.14
unnamed: J2.15, R9.1
unnamed: J2.16, J7.16
unnamed: J2.17, R8.1
unnamed: J2.18, J7.18
unnamed: J2.19, R7.1
unnamed: J2.20, J7.20
unnamed: J2.21, R6.1
unnamed: J2.22, J7.22
unnamed: J2.23, R5.1
unnamed: J2.24, J7.24
unnamed: J2.25, R4.1
unnamed: J2.26, J7.26
unnamed: J2.27, R3.1
unnamed: J2.28, J7.28
unnamed: J2.29, R2.1
unnamed: J2.30, J7.30
unnamed: J2.31, R1.1
unnamed: J2.32, J7.32
OUT0: R1.2; also elsewhere on the board
OUT1: R2.2; also elsewhere on the board
OUT2: R3.2; also elsewhere on the board
OUT3: R4.2; also elsewhere on the board
OUT4: R5.2; also elsewhere on the board
OUT5: R6.2; also elsewhere on the board
OUT6: R7.2; also elsewhere on the board
OUT7: R8.2; also elsewhere on the board
OUT8: R9.2; also elsewhere on the board
OUT9: R10.2; also elsewhere on the board
OUT10: R11.2; also elsewhere on the board
OUT11: R12.2; also elsewhere on the board
OUT12: R13.2; also elsewhere on the board
OUT13: R14.2; also elsewhere on the board
OUT14: R15.2; also elsewhere on the board
OUT15: R16.2; also elsewhere on the board
RD_CLK: J3.34; also elsewhere on the board
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C17.1, D1.2 (A), J1.38, J1.40, J2.38, J2.40, J3.38, J3.40, J5.2; also elsewhere on the board
WR_CLK: J3.36; also elsewhere on the board
Y_SEL: J3.35, J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, J6.13, J6.15, J6.17, J6.19, J6.21, J6.23, J6.25, J6.27, J6.29, J6.31; also elsewhere on the board
phi1: J1.36; also elsewhere on the board
phi2: J1.34; also elsewhere on the board

Notes on the sheet:
OUTPUT - Data 16bit - Address 16bit - phi1 1bit - phi2 1bit - RD 1bit - WR 1bit
Writeサイクル ・phi2で転送先MEMアドレス確定 ・phi1で転送元Regアドレス確定 ・phi1立下りでTMP Regに転送元データ転送完了 ・phi2で転送先Regアドレス確定 ・phi2立下りでMEMにデータ転送完了
リードサイクル アドレス確定，RD→L phi1にパルス TMPへ転送 RD→H
A_SEL -> RD Y_SEL -> WE
RDはデバイス側のOEに接続
・phi2でアドレス確定 ・phi1でRegアドレス確定 ・phi1立下りでTMP Regにデータ転送完了 ・phi2で転送先Regに転送完了
WR,RDはReg Addrから生成されるアサート信号
ライトサイクル アドレス確定，WR→L phi2にパルス，WRとANDを取って書き込みパルス WR→H
phi1,2を供給し，各デバイスでENを検知する

Parts:
C9, C10, C12, C13, C14, C15, C16: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
J8, J9: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Horizontal
U13, U14, U15, U16, U19, U20: CD74HC00; DIP-14_W7.62mm
U23, U24: TC551001; DIP-32_W15.24mm

Connections:
GND: C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, U13.7 (GND), U14.7 (GND), U15.7 (GND), U16.7 (GND), U19.7 (GND), U20.7 (GND), U23.16 (GND), U24.16 (GND); also elsewhere on the board
VCC: C9.1, C10.1, C12.1, C13.1, C14.1, C15.1, C16.1, U13.14 (VCC), U14.14 (VCC), U15.14 (VCC), U16.14 (VCC), U19.14 (VCC), U20.14 (VCC), U23.32 (VCC), U24.32 (VCC); also elsewhere on the board
